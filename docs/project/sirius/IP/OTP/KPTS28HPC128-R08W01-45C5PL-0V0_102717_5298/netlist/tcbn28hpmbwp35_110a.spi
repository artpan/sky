************************************************************************************
* TSMC Library/IP Product
* Filename: tcbn28hpmbwp35_110a.spi
* Technology: CLN28HM
* Product Type: Standard Cell
* Product Name: tcbn28hpmbwp35
* Version: 110a
*************************************************************************************
**
*  STATEMENT OF USE
*
*  This information contains confidential and proprietary information of TSMC.
*  No part of this information may be reproduced, transmitted, transcribed,
*  stored in a retrieval system, or translated into any human or computer
*  language, in any form or by any means, electronic, mechanical, magnetic,
*  optical, chemical, manual, or otherwise, without the prior written permission
*  of TSMC.  This information was prepared for informational purpose and is for
*  use by TSMC's customers only.  TSMC reserves the right to make changes in the
*  information at any time and without notice.
*
**************************************************************************************
***ewave
***^XMM--->MM
***ewave
.subckt AN2D0BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN2D16BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=5
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt AN2D1BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=170n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN2D2BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN2D4BWP35 A1 A2 Z VDD VSS
MM0 net027 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net027 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AN2D6BWP35 A1 A2 Z VDD VSS
MM14 net036 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net26 A1 net036 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AN2D8BWP35 A1 A2 Z VDD VSS
MM3 net027 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net26 A1 net027 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt AN2XD0BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN2XD16BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=8
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt AN2XD1BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN2XD2BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN2XD4BWP35 A1 A2 Z VDD VSS
MM0 net036 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net036 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AN2XD6BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=3
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AN2XD8BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=4
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt AN3D0BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN3D16BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=5
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=5
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt AN3D1BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN3D2BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN3D4BWP35 A1 A2 A3 Z VDD VSS
MM0 net037 A2 net029 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net037 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net029 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN3D6BWP35 A1 A2 A3 Z VDD VSS
MM0 net048 A2 net040 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net048 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net040 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN3D8BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=3
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=3
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt AN3XD0BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN3XD16BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=8
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=8
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt AN3XD1BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN3XD2BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN3XD4BWP35 A1 A2 A3 Z VDD VSS
MM0 net048 A2 net040 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A1 net048 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net040 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN3XD6BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=3
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=3
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt AN3XD8BWP35 A1 A2 A3 Z VDD VSS
MM13 net028 A2 net024 VSS nch_mac l=35.0n w=280.0n m=4
MM14 net26 A1 net028 VSS nch_mac l=35.0n w=280.0n m=4
MM12 net024 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM10 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM15 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM11 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AN4D0BWP35 A1 A2 A3 A4 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=140.0n m=1
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=140.0n m=1
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN4D1BWP35 A1 A2 A3 A4 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=140.0n m=1
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=140.0n m=1
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AN4D2BWP35 A1 A2 A3 A4 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=280.0n m=1
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AN4D4BWP35 A1 A2 A3 A4 Z VDD VSS
MM0 net26 A1 net037 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net041 A3 net033 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net037 A2 net041 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net033 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=280.0n m=1
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AN4D8BWP35 A1 A2 A3 A4 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=280.0n m=3
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=280.0n m=3
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=280.0n m=3
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt AN4XD1BWP35 A1 A2 A3 A4 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net26 A1 net030 VSS nch_mac l=35.0n w=280.0n m=1
MM20 net034 A3 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM19 net030 A2 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM21 net038 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net26 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net26 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt ANTENNABWP35 I VDD VSS
DD0 VSS I ndio area=5.04e-14 pj=9.2e-07 m=1
.ends
.subckt AO211D0BWP35 A1 A2 B C Z VDD VSS
MM5 Z net44 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net44 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net44 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net44 A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net44 A1 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net44 A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO211D1BWP35 A1 A2 B C Z VDD VSS
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net44 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net44 A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO211D2BWP35 A1 A2 B C Z VDD VSS
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net44 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net44 A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO211D4BWP35 A1 A2 B C Z VDD VSS
MM12 net44 A1 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net034 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net44 C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net44 A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net065 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net47 B net065 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO21D0BWP35 A1 A2 B Z VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net11 A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net11 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net11 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net34 B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net11 A2 net34 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net11 A1 net34 VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net11 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO21D1BWP35 A1 A2 B Z VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net11 A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net11 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net34 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A2 net34 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net11 A1 net34 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO21D2BWP35 A1 A2 B Z VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net11 A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net11 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net34 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A2 net34 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net11 A1 net34 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO21D4BWP35 A1 A2 B Z VDD VSS
MM8 net034 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net11 A1 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net11 A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net11 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net34 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net11 A2 net34 VDD pch_mac l=35.0n w=340.0n m=2
MM3 net11 A1 net34 VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AO221D0BWP35 A1 A2 B1 B2 C Z VDD VSS
MM10 Z net53 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net53 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net53 B1 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net53 A1 net29 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 Z net53 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net36 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net53 A1 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net53 A2 net56 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO221D1BWP35 A1 A2 B1 B2 C Z VDD VSS
MM10 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net53 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO221D2BWP35 A1 A2 B1 B2 C Z VDD VSS
MM10 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net53 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO221D4BWP35 A1 A2 B1 B2 C Z VDD VSS
MM12 net53 A1 net043 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net043 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net039 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net53 B1 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net53 C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=2
MM6 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO222D0BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM12 net22 C1 net38 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net22 A1 net50 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net22 B1 net62 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 Z net22 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net22 A2 net25 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net22 A1 net25 VDD pch_mac l=35.0n w=170.0n m=1
MM11 Z net22 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO222D1BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM12 net22 C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net22 A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net22 B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net22 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net22 A2 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net22 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM11 Z net22 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO222D2BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM12 net22 C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net22 A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net22 B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net22 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net22 A2 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net22 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM11 Z net22 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO222D4BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM14 net22 B1 net084 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net084 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net22 C1 net076 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net076 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net072 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net22 A1 net072 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net22 C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net22 A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net22 B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net22 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net22 A2 net25 VDD pch_mac l=35.0n w=340.0n m=2
MM6 net22 A1 net25 VDD pch_mac l=35.0n w=340.0n m=2
MM11 Z net22 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=2
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO22D0BWP35 A1 A2 B1 B2 Z VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=135.00n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=135.00n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net24 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO22D16BWP35 A1 A2 B1 B2 Z VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=5
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=5
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=5
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=5
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt AO22D1BWP35 A1 A2 B1 B2 Z VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO22D2BWP35 A1 A2 B1 B2 Z VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO22D4BWP35 A1 A2 B1 B2 Z VDD VSS
MM10 net050 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net24 A1 net050 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net042 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net24 B1 net042 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AO22D6BWP35 A1 A2 B1 B2 Z VDD VSS
MM10 net063 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net24 A1 net063 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net055 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net24 B1 net055 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AO22D8BWP35 A1 A2 B1 B2 Z VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM7 net24 B1 net16 VSS nch_mac l=35.0n w=280.0n m=3
MM6 net24 A1 net12 VSS nch_mac l=35.0n w=280.0n m=3
MM5 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM3 net24 A2 net39 VDD pch_mac l=35.0n w=340.0n m=3
MM2 net24 A1 net39 VDD pch_mac l=35.0n w=340.0n m=3
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt AO31D0BWP35 A1 A2 A3 B Z VDD VSS
MM0 net44 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net44 A1 net20 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net44 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net47 B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net44 A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net44 A1 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net44 A3 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO31D1BWP35 A1 A2 A3 B Z VDD VSS
MM0 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 A1 net20 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net44 A3 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO31D2BWP35 A1 A2 A3 B Z VDD VSS
MM0 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 A1 net20 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net44 A3 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO31D4BWP35 A1 A2 A3 B Z VDD VSS
MM6 net44 A1 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net44 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net042 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net038 A2 net042 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 A1 net20 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net44 A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM11 net44 A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM15 net44 A3 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AO32D0BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM5 Z net53 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net53 B1 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO32D1BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO32D2BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO32D4BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM0 net050 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net046 A2 net050 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net53 A1 net046 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net53 B1 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net034 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AO33D0BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net53 B1 net035 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AO33D1BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net53 B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO33D2BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net53 B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AO33D4BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM16 net53 A1 net054 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net046 B2 net042 VSS nch_mac l=35.0n w=280.0n m=1
MM18 net042 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net53 B1 net046 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net058 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net53 B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net054 A2 net058 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI211D0BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=170.0n m=1
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI211D16BWP35 A1 A2 B C ZN VDD VSS
MM10 ZN net073 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net073 net072 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM0 net072 C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net072 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net072 A1 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 ZN net073 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 net073 net072 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=2
MM6 net072 A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net072 A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI211D1BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI211D2BWP35 A1 A2 B C ZN VDD VSS
MM10 ZN A1 net033 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net033 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net47 B net047 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net047 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI211D4BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=4
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI211D6BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=6
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=6
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=6
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=6
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AOI211D8BWP35 A1 A2 B C ZN VDD VSS
MM5 net043 net080 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM10 ZN net043 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 net080 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net080 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net080 A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 ZN net043 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net043 net080 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net080 A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net080 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI211OPTREPBD12BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=18 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt AOI211OPTREPBD16BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt AOI211OPTREPBD1BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt AOI211OPTREPBD2BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=3 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt AOI211OPTREPBD4BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt AOI211OPTREPBD6BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=9 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt AOI211OPTREPBD8BWP35 A1 A2 B C ZN VDD VSS
XMP12 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP21 net037 C net051 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 net051 A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN13 ZN C VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt AOI211XD0BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI211XD16BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=32
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=32
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=32
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=32
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=32
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=32
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=32
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=32
.ends
.subckt AOI211XD1BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI211XD2BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=4
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI211XD4BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=8
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=8
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt AOI211XD6BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=12
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=12
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=12
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=12
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=12
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=12
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt AOI211XD8BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=16
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=16
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=16
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=16
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt AOI21D0BWP35 A1 A2 B ZN VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI21D16BWP35 A1 A2 B ZN VDD VSS
MM9 ZN net045 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net045 net050 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net050 A1 net7 VSS nch_mac l=35.0n w=280.0n m=2
MM0 net050 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net045 net050 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM8 ZN net045 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net050 A2 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM3 net050 A1 net30 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI21D1BWP35 A1 A2 B ZN VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI21D2BWP35 A1 A2 B ZN VDD VSS
MM5 ZN A1 net027 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net027 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI21D4BWP35 A1 A2 B ZN VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI21D6BWP35 A1 A2 B ZN VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=280.0n m=6
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=6
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AOI21D8BWP35 A1 A2 B ZN VDD VSS
MM4 net033 net042 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN net033 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net042 A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net042 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net033 net042 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM8 ZN net033 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net042 A2 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net042 A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI21OPTPBD12BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt AOI21OPTPBD16BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt AOI21OPTPBD1BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt AOI21OPTPBD2BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt AOI21OPTPBD4BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt AOI21OPTPBD6BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt AOI21OPTPBD8BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A2 net040 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP31 net040 B VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt AOI21OPTREPBD12BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt AOI21OPTREPBD16BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt AOI21OPTREPBD1BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt AOI21OPTREPBD2BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt AOI21OPTREPBD4BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt AOI21OPTREPBD6BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt AOI21OPTREPBD8BWP35 A1 A2 B ZN VDD VSS
XMP12 net037 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP31 ZN B net037 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 net037 A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN21 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 ZN B VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt AOI221D0BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM5 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B1 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net29 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net36 C net56 VDD pch_mac l=35.0n w=240.0n m=1
MM3 net56 B2 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM2 net56 B1 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM6 ZN A1 net36 VDD pch_mac l=35.0n w=240.0n m=1
MM7 ZN A2 net36 VDD pch_mac l=35.0n w=240.0n m=1
.ends
.subckt AOI221D1BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM5 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net36 C net56 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A2 net36 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI221D2BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM11 ZN A1 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net038 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net034 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN B1 net034 VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM7 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI221D4BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM11 net030 net082 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN net030 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net082 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net082 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net082 A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net030 net082 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 ZN net030 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net082 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net082 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI221XD4BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM5 ZN C VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A1 net29 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net29 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net36 C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net56 B2 net36 VDD pch_mac l=35.0n w=340.0n m=4
MM2 net56 B1 net36 VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=4
MM7 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI222D0BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM12 ZN C1 net38 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net50 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B1 net62 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 ZN A2 net25 VDD pch_mac l=35.0n w=170.0n m=1
MM6 ZN A1 net25 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI222D1BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM12 ZN C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A2 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI222D2BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM14 ZN B1 net075 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net075 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 ZN C1 net067 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net067 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net063 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 ZN A1 net063 VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 ZN A2 net25 VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A1 net25 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=2
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI222D4BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM11 net071 net051 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN net071 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net051 C1 net38 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net051 A1 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net051 B1 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net071 net051 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN net071 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net051 A2 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net051 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI222XD4BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM12 ZN C1 net38 VSS nch_mac l=35.0n w=280.0n m=4
MM13 net38 C2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net50 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A1 net50 VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN B1 net62 VSS nch_mac l=35.0n w=280.0n m=4
MM1 net62 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net37 C1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 net37 C2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 ZN A2 net25 VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A1 net25 VDD pch_mac l=35.0n w=340.0n m=4
MM2 net25 B1 net37 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net25 B2 net37 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI22D16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 ZN net046 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net046 net059 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net059 B1 net16 VSS nch_mac l=35.0n w=280.0n m=2
MM6 net059 A1 net12 VSS nch_mac l=35.0n w=280.0n m=2
MM10 ZN net046 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM5 net046 net059 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM3 net059 A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net059 A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM10 net043 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 ZN A1 net043 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net035 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=280.0n m=4
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=280.0n m=4
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI22D6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=280.0n m=6
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=280.0n m=6
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=6
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=6
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt AOI22D8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 ZN net046 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net046 net059 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net059 B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net059 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM10 ZN net046 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM5 net046 net059 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net059 A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net059 A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI22OPTPBD12BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt AOI22OPTPBD16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt AOI22OPTPBD1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt AOI22OPTPBD2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt AOI22OPTPBD4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt AOI22OPTPBD6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt AOI22OPTPBD8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A2 net037 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM3 ZN A1 net037 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM9 net037 B2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 net037 B1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM2 net0119 B2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM5 net022 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM28 ZN B1 net0119 VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt AOI31D0BWP35 A1 A2 A3 B ZN VDD VSS
MM0 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN A1 net20 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net47 B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM11 ZN A1 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM15 ZN A3 net47 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI31D1BWP35 A1 A2 A3 B ZN VDD VSS
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net20 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A3 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI31D2BWP35 A1 A2 A3 B ZN VDD VSS
MM2 net035 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net031 A2 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net031 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net20 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM15 ZN A3 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI31D4BWP35 A1 A2 A3 B ZN VDD VSS
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM13 net20 A2 net16 VSS nch_mac l=35.0n w=280.0n m=4
MM14 ZN A1 net20 VSS nch_mac l=35.0n w=280.0n m=4
MM1 net47 B VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=4
MM11 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=4
MM15 ZN A3 net47 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI32D0BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM8 ZN B1 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI32D1BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM8 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI32D2BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM0 net046 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net042 A2 net046 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net042 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN B1 net030 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net030 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI32D4BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM0 ZN net038 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net038 net53 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 B1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net53 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN net038 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net038 net53 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net53 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net53 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net53 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI32XD4BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM8 ZN B1 net17 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net17 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=4
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=4
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=4
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=4
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt AOI33D0BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 net035 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt AOI33D1BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI33D2BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM8 ZN A1 net050 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net042 B2 net038 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net038 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 ZN B1 net042 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net054 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net050 A2 net054 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt AOI33D4BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM5 net034 net094 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN net034 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net094 B1 net035 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net094 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net034 net094 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN net034 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net094 A2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net094 A1 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net094 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt AOI33XD4BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM1 net035 B2 net039 VSS nch_mac l=35.0n w=280.0n m=4
MM0 net039 B3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN B1 net035 VSS nch_mac l=35.0n w=280.0n m=4
MM12 net21 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM13 net25 A2 net21 VSS nch_mac l=35.0n w=280.0n m=4
MM14 ZN A1 net25 VSS nch_mac l=35.0n w=280.0n m=4
MM3 net56 B3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net56 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN A2 net56 VDD pch_mac l=35.0n w=340.0n m=4
MM11 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=4
MM15 ZN A3 net56 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt BHDBWP35 Z VDD VSS
MM0 net4 Z VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net4 Z VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net4 VDD VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt BUFFD0BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt BUFFD12BWP35 I Z VDD VSS
MM0 Z net55 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM19 net55 I VSS VSS nch_mac l=35.0n w=280.0n m=4
MM21 net55 I VDD VDD pch_mac l=35.0n w=340.0n m=4
MM20 Z net55 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt BUFFD16BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=5
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt BUFFD1BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt BUFFD20BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=20
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=20
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt BUFFD24BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=24
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=7
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=24
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=7
.ends
.subckt BUFFD2BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFFD3BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFFD4BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt BUFFD6BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt BUFFD8BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt BUFFXD0BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=100n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=130.0n m=1
.ends
.subckt BUFFXD12BWP35 I Z VDD VSS
MM0 Z net55 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM19 net55 I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM21 net55 I VDD VDD pch_mac l=35.0n w=340.0n m=6
MM20 Z net55 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt BUFFXD16BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=8
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt BUFFXD1BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt BUFFXD2BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFFXD3BWP35 I Z VDD VSS
MM3 net9 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net9 I VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFFXD4BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt BUFFXD6BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt BUFFXD8BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt BUFTD0BWP35 I OE Z VDD VSS
MM11 INEP I net10 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 INEN net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net26 OE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 INEP OE VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net49 net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=170.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net26 OE VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt BUFTD12BWP35 I OE Z VDD VSS
MM6 net93 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net85 net81 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 Z net85 VSS VSS nch_mac l=35.0n w=210.0n m=12
MM7 net113 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net85 net81 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net81 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net105 I net113 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net105 I net93 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net85 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net85 I VSS VSS nch_mac l=35.0n w=210.0n m=1
MM16 net81 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net85 net81 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net85 net81 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net105 I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM18 Z net105 VDD VDD pch_mac l=35.0n w=270.0n m=12
MM10 net56 I VDD VDD pch_mac l=35.0n w=270.0n m=1
MM9 net60 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net105 OE VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt BUFTD16BWP35 I OE Z VDD VSS
MM16 INEN I VSS VSS nch_mac l=35.0n w=210.0n m=1
MM12 INEP I net038 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net038 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN net075 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=16
MM5 net075 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net078 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 INEN net075 net078 VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net49 I VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN net075 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=16
MM4 net075 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD1BWP35 I OE Z VDD VSS
MM5 net53 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net69 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net69 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 INEN net53 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net83 net53 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 INEN I net83 VDD pch_mac l=35.0n w=340.0n m=1
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net53 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD20BWP35 I OE Z VDD VSS
MM20 INEN net0122 VSS VSS nch_mac l=35.0n w=200n m=1
MM14 INEP I net043 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net043 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 INEP I net038 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net038 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 INEN net0122 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 Z INEN VSS VSS nch_mac l=35.0n w=200n m=20
MM5 net0122 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net094 net0122 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM17 INEN I net094 VDD pch_mac l=35.0n w=340.0n m=1
MM18 INEN I net090 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net090 net0122 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=3
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net49 net0122 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=20
MM4 net0122 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD24BWP35 I OE Z VDD VSS
MM20 INEN net26 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM14 INEP I net043 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net043 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 INEP I net038 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net038 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 INEN net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=24
MM5 net26 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net094 net26 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM17 INEN I net094 VDD pch_mac l=35.0n w=340.0n m=1
MM18 INEN I net090 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net090 net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=3
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net49 net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=24
MM4 net26 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD2BWP35 I OE Z VDD VSS
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 INEN net26 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=2
MM5 net26 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net49 net26 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=2
MM4 net26 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD3BWP35 I OE Z VDD VSS
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 INEN net26 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=3
MM5 net26 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net49 net26 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=3
MM4 net26 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD4BWP35 I OE Z VDD VSS
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 INEN net26 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=4
MM5 net26 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net49 net26 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN I net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=4
MM4 net26 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD6BWP35 I OE Z VDD VSS
MM16 INEN I VSS VSS nch_mac l=35.0n w=210.0n m=1
MM12 INEP I net038 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net038 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN net075 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=6
MM5 net075 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net078 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 INEN net075 net078 VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net49 I VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN net075 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=6
MM4 net075 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt BUFTD8BWP35 I OE Z VDD VSS
MM16 INEN I VSS VSS nch_mac l=35.0n w=210.0n m=1
MM12 INEP I net038 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net038 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 INEP I net10 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net10 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 INEN net075 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 INEN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z INEN VSS VSS nch_mac l=35.0n w=210.0n m=8
MM5 net075 OE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net078 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 INEN net075 net078 VDD pch_mac l=35.0n w=340.0n m=1
MM9 INEP I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 INEP OE VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net49 I VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 INEN net075 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z INEP VDD VDD pch_mac l=35.0n w=270.0n m=8
MM4 net075 OE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKAN2D0BWP35 A1 A2 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=180.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=240.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=240.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt CKAN2D1BWP35 A1 A2 Z VDD VSS
XMXM1 _SP_9 A1 _SP_17 VSS nch_mac w=0.24u l=0.035u
XMXM2 VSS A2 _SP_9 VSS nch_mac w=0.24u l=0.035u
XMXM3 Z _SP_17 VSS VSS nch_mac w=0.28u l=0.035u
XMXM4 _SP_17 A1 VDD VDD pch_mac w=0.175u l=0.035u
XMXM5 VDD A2 _SP_17 VDD pch_mac w=0.175u l=0.035u
XMXM6 Z _SP_17 VDD VDD pch_mac w=0.34u l=0.035u
.ends
.subckt CKAN2D2BWP35 A1 A2 Z VDD VSS
XMXM1 _SP_11 A1 _SP_19 VSS nch_mac w=0.255u l=0.035u
XMXM2 VSS A2 _SP_11 VSS nch_mac w=0.255u l=0.035u
XMXM3 Z _SP_19 VSS VSS nch_mac w=0.28u l=0.035u
XMXM4 VSS _SP_19 Z VSS nch_mac w=0.28u l=0.035u
XMXM5 _SP_19 A1 VDD VDD pch_mac w=0.18u l=0.035u
XMXM6 VDD A2 _SP_19 VDD pch_mac w=0.18u l=0.035u
XMXM7 Z _SP_19 VDD VDD pch_mac w=0.34u l=0.035u
XMXM8 VDD _SP_19 Z VDD pch_mac w=0.34u l=0.035u
.ends
.subckt CKAN2D4BWP35 A1 A2 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=185.00n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt CKAN2D8BWP35 A1 A2 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=185.00n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt CKBD0BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt CKBD12BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM5 net9 I VSS VSS nch_mac l=35.0n w=275.00n m=4
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt CKBD16BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net9 I VSS VSS nch_mac l=35.0n w=275.00n m=5
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt CKBD1BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKBD20BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=20
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=20
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt CKBD24BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=24
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=7
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=24
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=7
.ends
.subckt CKBD2BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net9 I VSS VSS nch_mac l=35.0n w=255.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKBD3BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net9 I VSS VSS nch_mac l=35.0n w=250.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKBD4BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net9 I VSS VSS nch_mac l=35.0n w=270.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt CKBD6BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM5 net9 I VSS VSS nch_mac l=35.0n w=270.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt CKBD8BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net9 I VSS VSS nch_mac l=35.0n w=270.0n m=3
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt CKLHQD12BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=140.0n m=3
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0134 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM35 net11 CPN net0134 VDD pch_mac l=35.0n w=340.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD16BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=140.0n m=4
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM36 net0136 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 net11 CPN net0136 VDD pch_mac l=35.0n w=340.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0134 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM35 net11 CPN net0134 VDD pch_mac l=35.0n w=340.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD1BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD20BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=140.0n m=4
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=20
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM36 net0136 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 net11 CPN net0136 VDD pch_mac l=35.0n w=340.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0134 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=20
MM35 net11 CPN net0134 VDD pch_mac l=35.0n w=340.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD24BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=140.0n m=5
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=24
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net0137 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 net11 CPN net0137 VDD pch_mac l=35.0n w=340.0n m=1
MM36 net0136 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 net11 CPN net0136 VDD pch_mac l=35.0n w=340.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0134 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=24
MM35 net11 CPN net0134 VDD pch_mac l=35.0n w=340.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD2BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=150.0n m=1
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD3BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=150.0n m=1
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD4BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=140.0n m=2
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD6BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=135.00n m=2
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=135.00n m=2
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLHQD8BWP35 Q TE CPN E VDD VSS
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkb net0190 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net11 CPN VSS VSS nch_mac l=35.0n w=135.00n m=2
MM21 net11 net51 VSS VSS nch_mac l=35.0n w=135.00n m=2
MM18 Q net11 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net51 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net0190 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net37 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net37 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkbb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0127 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net11 CPN net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net0245 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM24 qf_x clkbb net0245 VDD pch_mac l=35.0n w=140.0n m=1
MM20 net56 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 CPN net56 VDD pch_mac l=35.0n w=340.0n m=1
MM17 Q net11 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net51 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf_x clkb net88 VDD pch_mac l=35.0n w=140.0n m=1
MM0 net88 E net92 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net92 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKLNQD12BWP35 TE E CP Q VDD VSS
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=180.0n m=2
MM6 net39 CP VDD VDD pch_mac l=35.0n w=180.0n m=2
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt CKLNQD16BWP35 TE E CP Q VDD VSS
MM15 net072 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net39 CP net072 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=170.0n m=3
MM6 net39 CP VDD VDD pch_mac l=35.0n w=170.0n m=3
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt CKLNQD1BWP35 TE E CP Q VDD VSS
XMXM1 _SP_65 CP _SP_99 VSS nch_mac w=0.255u l=0.035u
XMXM2 VSS _SP_102 _SP_65 VSS nch_mac w=0.255u l=0.035u
XMXM3 Q _SP_99 VSS VSS nch_mac w=0.24u l=0.035u
XMXM4 VSS _SP_104 _SP_103 VSS nch_mac w=0.14u l=0.035u
XMXM5 _SP_104 CP VSS VSS nch_mac w=0.14u l=0.035u
XMXM6 VSS _SP_102 _SP_64 VSS nch_mac w=0.14u l=0.035u
XMXM7 _SP_102 _SP_91 VSS VSS nch_mac w=0.14u l=0.035u
XMXM8 VSS TE _SP_105 VSS nch_mac w=0.28u l=0.035u
XMXM9 VSS E _SP_105 VSS nch_mac w=0.28u l=0.035u
XMXM10 _SP_91 _SP_104 _SP_105 VSS nch_mac w=0.14u l=0.035u
XMXM11 _SP_64 _SP_103 _SP_91 VSS nch_mac w=0.14u l=0.035u
XMXM12 _SP_99 CP VDD VDD pch_mac w=0.2u l=0.035u
XMXM13 _SP_99 _SP_102 VDD VDD pch_mac w=0.2u l=0.035u
XMXM14 Q _SP_99 VDD VDD pch_mac w=0.33u l=0.035u
XMXM15 _SP_91 _SP_103 _SP_88 VDD pch_mac w=0.14u l=0.035u
XMXM16 _SP_51 _SP_104 _SP_91 VDD pch_mac w=0.14u l=0.035u
XMXM17 VDD _SP_102 _SP_51 VDD pch_mac w=0.14u l=0.035u
XMXM18 _SP_102 _SP_91 VDD VDD pch_mac w=0.175u l=0.035u
XMXM19 VDD _SP_104 _SP_103 VDD pch_mac w=0.17u l=0.035u
XMXM20 _SP_104 CP VDD VDD pch_mac w=0.17u l=0.035u
XMXM21 _SP_49 TE VDD VDD pch_mac w=0.34u l=0.035u
XMXM22 _SP_88 E _SP_49 VDD pch_mac w=0.34u l=0.035u
.ends
.subckt CKLNQD20BWP35 TE E CP Q VDD VSS
MM19 net0127 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net39 CP net0127 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net072 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net39 CP net072 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=20
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=175.00n m=4
MM6 net39 CP VDD VDD pch_mac l=35.0n w=175.00n m=4
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=20
.ends
.subckt CKLNQD24BWP35 TE E CP Q VDD VSS
MM19 net0127 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net39 CP net0127 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net072 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net39 CP net072 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=24
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=175.00n m=4
MM6 net39 CP VDD VDD pch_mac l=35.0n w=175.00n m=4
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=24
.ends
.subckt CKLNQD2BWP35 TE E CP Q VDD VSS
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=180.0n m=1
MM6 net39 CP VDD VDD pch_mac l=35.0n w=180.0n m=1
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt CKLNQD3BWP35 TE E CP Q VDD VSS
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM6 net39 CP VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt CKLNQD4BWP35 TE E CP Q VDD VSS
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM6 net39 CP VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt CKLNQD6BWP35 TE E CP Q VDD VSS
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net0186 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net0186 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=185.00n m=2
MM6 net39 CP VDD VDD pch_mac l=35.0n w=185.00n m=2
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt CKLNQD8BWP35 TE E CP Q VDD VSS
MM3 net0121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 CP net0121 VSS nch_mac l=35.0n w=280.0n m=1
MM5 qf_x clkb net59 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net59 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 net59 TE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 qf_x clkbb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net75 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net83 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net39 CP net83 VSS nch_mac l=35.0n w=280.0n m=1
MM18 Q net39 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net14 TE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net18 E net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x clkbb net18 VDD pch_mac l=35.0n w=140.0n m=1
MM12 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 qf_x clkb net30 VDD pch_mac l=35.0n w=140.0n m=1
MM25 net30 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM7 net39 qf VDD VDD pch_mac l=35.0n w=185.00n m=2
MM6 net39 CP VDD VDD pch_mac l=35.0n w=185.00n m=2
MM17 Q net39 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt CKLNQOPTMAD16BWP35 TE E CP Q VDD VSS
MM3 net103 TE net111 VSS nch_mac l=35n w=210.0n m=1 nf=1
XMN_CTL_T1S2 net131 net139 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPINV_T2S1 net122 net103 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPCK_T3S2 VSS net122 net123 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_DPCK_T3S1 net123 CP_plus net103 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_LH1FB_T1S2 net180 CP net104 VSS nch_mac l=35n w=280.0n m=3 nf=1
XMN_DPIN_T1S2 net111 CPDN VSS VSS nch_mac l=35n w=210.0n m=4 nf=1
XMN_LH1FB_T1S3 net104 net122 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
XMN_DPIN_T1S1 net103 E net111 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPOUT_T4S1 Q net180 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN_CTL_T1S1 CTRL CP_minus net131 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_SEINV_T1S1 net139 TE VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 CPDN CP_plus VSS VSS nch_mac l=35n w=200n m=1 nf=1
XMP_LH1FB_T1S2B net180 net122 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP_DPINV_T2S1 net122 net103 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_LH1FB_T1S2A net180 CP VDD VDD pch_mac l=35n w=180.0n m=3 nf=1
XMP_DPOUT_T4S1 Q net180 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S2 net151 CTRL VDD VDD pch_mac l=35n w=270.0n m=4 nf=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S1 net103 E net151 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM4 CPDN CP_plus VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPCK_T3S2 VDD net122 net188 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_SEINV_T1S1 net139 TE VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPCK_T3S1 net188 CPDN net103 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_CTL_T1S1B CTRL net139 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt CKLNQOPTMAD1BWP35 TE E CP Q VDD VSS
MM3 net103 TE net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CTL_T1S2 net131 net139 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPINV_T2S1 net122 net103 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPCK_T3S2 VSS net122 net123 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_DPCK_T3S1 net123 CP_plus net103 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_LH1FB_T1S2 net180 CP net104 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPIN_T1S2 net111 CPDN VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
XMN_LH1FB_T1S3 net104 net122 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPIN_T1S1 net103 E net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPOUT_T4S1 Q net180 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CTL_T1S1 CTRL CP_minus net131 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_SEINV_T1S1 net139 TE VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 CPDN CP_plus VSS VSS nch_mac l=35n w=200n m=1 nf=1
XMP_LH1FB_T1S2B net180 net122 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPINV_T2S1 net122 net103 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_LH1FB_T1S2A net180 CP VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPOUT_T4S1 Q net180 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S2 net151 CTRL VDD VDD pch_mac l=35n w=235.00n m=2 nf=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S1 net103 E net151 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM4 CPDN CP_plus VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPCK_T3S2 VDD net122 net188 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_SEINV_T1S1 net139 TE VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPCK_T3S1 net188 CPDN net103 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_CTL_T1S1B CTRL net139 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt CKLNQOPTMAD2BWP35 TE E CP Q VDD VSS
MM3 net103 TE net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CTL_T1S2 net131 net139 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPINV_T2S1 net122 net103 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPCK_T3S2 VSS net122 net123 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_DPCK_T3S1 net123 CP_plus net103 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_LH1FB_T1S2 net180 CP net104 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPIN_T1S2 net111 CPDN VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
XMN_LH1FB_T1S3 net104 net122 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPIN_T1S1 net103 E net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPOUT_T4S1 Q net180 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN_CTL_T1S1 CTRL CP_minus net131 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_SEINV_T1S1 net139 TE VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 CPDN CP_plus VSS VSS nch_mac l=35n w=200n m=1 nf=1
XMP_LH1FB_T1S2B net180 net122 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPINV_T2S1 net122 net103 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_LH1FB_T1S2A net180 CP VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPOUT_T4S1 Q net180 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S2 net151 CTRL VDD VDD pch_mac l=35n w=235.00n m=2 nf=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S1 net103 E net151 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM4 CPDN CP_plus VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPCK_T3S2 VDD net122 net188 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_SEINV_T1S1 net139 TE VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPCK_T3S1 net188 CPDN net103 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_CTL_T1S1B CTRL net139 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt CKLNQOPTMAD4BWP35 TE E CP Q VDD VSS
MM3 net103 TE net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CTL_T1S2 net131 net139 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPINV_T2S1 net122 net103 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPCK_T3S2 VSS net122 net123 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_DPCK_T3S1 net123 CP_plus net103 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_LH1FB_T1S2 net180 CP net104 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN_DPIN_T1S2 net111 CPDN VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
XMN_LH1FB_T1S3 net104 net122 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN_DPIN_T1S1 net103 E net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPOUT_T4S1 Q net180 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN_CTL_T1S1 CTRL CP_minus net131 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_SEINV_T1S1 net139 TE VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 CPDN CP_plus VSS VSS nch_mac l=35n w=200n m=1 nf=1
XMP_LH1FB_T1S2B net180 net122 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPINV_T2S1 net122 net103 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_LH1FB_T1S2A net180 CP VDD VDD pch_mac l=35n w=200n m=2 nf=1
XMP_DPOUT_T4S1 Q net180 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S2 net151 CTRL VDD VDD pch_mac l=35n w=235.00n m=2 nf=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S1 net103 E net151 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM4 CPDN CP_plus VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPCK_T3S2 VDD net122 net188 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_SEINV_T1S1 net139 TE VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPCK_T3S1 net188 CPDN net103 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_CTL_T1S1B CTRL net139 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt CKLNQOPTMAD8BWP35 TE E CP Q VDD VSS
MM3 net103 TE net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CTL_T1S2 net131 net139 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPINV_T2S1 net122 net103 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPCK_T3S2 VSS net122 net123 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_DPCK_T3S1 net123 CP_plus net103 VSS nch_mac l=35n w=200n m=1 nf=1
XMN_LH1FB_T1S2 net180 CP net104 VSS nch_mac l=35n w=280.0n m=3 nf=1
XMN_DPIN_T1S2 net111 CPDN VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
XMN_LH1FB_T1S3 net104 net122 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN_DPIN_T1S1 net103 E net111 VSS nch_mac l=35n w=245.00n m=1 nf=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_DPOUT_T4S1 Q net180 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN_CTL_T1S1 CTRL CP_minus net131 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN_SEINV_T1S1 net139 TE VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 CPDN CP_plus VSS VSS nch_mac l=35n w=200n m=1 nf=1
XMP_LH1FB_T1S2B net180 net122 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPINV_T2S1 net122 net103 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_LH1FB_T1S2A net180 CP VDD VDD pch_mac l=35n w=150.0n m=3 nf=1
XMP_DPOUT_T4S1 Q net180 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S2 net151 CTRL VDD VDD pch_mac l=35n w=235.00n m=2 nf=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPIN_T1S1 net103 E net151 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM4 CPDN CP_plus VDD VDD pch_mac l=35n w=200n m=1 nf=1
XMP_DPCK_T3S2 VDD net122 net188 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_SEINV_T1S1 net139 TE VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_DPCK_T3S1 net188 CPDN net103 VDD pch_mac l=35n w=200n m=1 nf=1
XMP_CTL_T1S1B CTRL net139 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt CKMUX2D0BWP35 I0 I1 S Z VDD VSS
MM10 Z net11 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net11 S net096 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net096 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net19 S VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net23 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net11 net19 net23 VSS nch_mac l=35.0n w=140.0n m=1
MM11 Z net11 VDD VDD pch_mac l=35.0n w=160.0n m=1
MM9 net11 net19 net15 VDD pch_mac l=35.0n w=170.0n m=1
MM8 net15 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net19 S VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net087 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net11 S net087 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt CKMUX2D1BWP35 I0 I1 S Z VDD VSS
XMXM1 VSS S _SP_57 VSS nch_mac w=0.125u l=0.035u
XMXM2 _SP_53 I0 VSS VSS nch_mac w=0.125u l=0.035u
XMXM3 _SP_56 _SP_57 _SP_53 VSS nch_mac w=0.14u l=0.035u
XMXM4 _SP_55 S _SP_56 VSS nch_mac w=0.14u l=0.035u
XMXM5 VSS I1 _SP_55 VSS nch_mac w=0.135u l=0.035u
XMXM6 Z _SP_56 VSS VSS nch_mac w=0.18u l=0.035u
XMXM7 _SP_56 S _SP_53 VDD pch_mac w=0.23u l=0.035u
XMXM8 _SP_55 _SP_57 _SP_56 VDD pch_mac w=0.23u l=0.035u
XMXM9 VDD I1 _SP_55 VDD pch_mac w=0.23u l=0.035u
XMXM10 Z _SP_56 VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 VDD S _SP_57 VDD pch_mac w=0.145u l=0.035u
XMXM12 _SP_53 I0 VDD VDD pch_mac w=0.23u l=0.035u
.ends
.subckt CKMUX2D2BWP35 I0 I1 S Z VDD VSS
MM10 Z net11 VSS VSS nch_mac l=35.0n w=250.0n m=2
MM7 net11 S net15 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net15 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net19 S VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net23 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net11 net19 net23 VSS nch_mac l=35.0n w=140.0n m=1
MM11 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 net11 net19 net15 VDD pch_mac l=35.0n w=200n m=1
MM8 net15 I1 VDD VDD pch_mac l=35.0n w=200n m=1
MM2 net19 S VDD VDD pch_mac l=35.0n w=220.0n m=1
MM0 net23 I0 VDD VDD pch_mac l=35.0n w=185.00n m=1
MM4 net11 S net23 VDD pch_mac l=35.0n w=200n m=1
.ends
.subckt CKMUX2D4BWP35 I0 I1 S Z VDD VSS
MM5 net52 I0 VSS VSS nch_mac l=35.0n w=180.0n m=2
MM6 Z net67 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM25 net52 net72 net67 VSS nch_mac l=35.0n w=205.00n m=1
MM9 net68 S net67 VSS nch_mac l=35.0n w=205.00n m=1
MM3 net68 I1 VSS VSS nch_mac l=35.0n w=180.0n m=2
MM0 net72 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net52 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 Z net67 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM24 net52 S net67 VDD pch_mac l=35.0n w=205.00n m=1
MM10 net68 net72 net67 VDD pch_mac l=35.0n w=205.00n m=1
MM1 net72 S VDD VDD pch_mac l=35.0n w=260.0n m=1
MM2 net68 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt CKND0BWP35 I ZN VDD VSS
XMXM1 VSS I ZN VSS nch_mac w=0.12u l=0.035u
XMXM2 VDD I ZN VDD pch_mac w=0.155u l=0.035u
.ends
.subckt CKND12BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=12
MM4 ZN I VDD VDD pch_mac l=35.0n w=310.0n m=12
.ends
.subckt CKND16BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 ZN I VDD VDD pch_mac l=35.0n w=305.00n m=16
.ends
.subckt CKND1BWP35 I ZN VDD VSS
XMXM1 VSS I ZN VSS nch_mac w=0.24u l=0.035u
XMXM2 VDD I ZN VDD pch_mac w=0.29u l=0.035u
.ends
.subckt CKND20BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=20
MM4 ZN I VDD VDD pch_mac l=35.0n w=300n m=20
.ends
.subckt CKND24BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=24
MM4 ZN I VDD VDD pch_mac l=35.0n w=295.00n m=24
.ends
.subckt CKND2BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=240.0n m=2
MM4 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt CKND2D0BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 net5 VSS nch_mac l=35.0n w=210.0n m=1
MM9 net5 A2 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM6 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt CKND2D1BWP35 A1 A2 ZN VDD VSS
XMXM1 _SP_1 A2 VSS VSS nch_mac w=0.28u l=0.035u
XMXM2 ZN A1 _SP_1 VSS nch_mac w=0.28u l=0.035u
XMXM3 ZN A2 VDD VDD pch_mac w=0.185u l=0.035u
XMXM4 VDD A1 ZN VDD pch_mac w=0.185u l=0.035u
.ends
.subckt CKND2D2BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 net5 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net5 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN A1 VDD VDD pch_mac l=35.0n w=185.00n m=2
MM7 ZN A2 VDD VDD pch_mac l=35.0n w=185.00n m=2
.ends
.subckt CKND2D3BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 net5 VSS nch_mac l=35.0n w=280.0n m=3
MM9 net5 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 ZN A1 VDD VDD pch_mac l=35.0n w=175.00n m=3
MM7 ZN A2 VDD VDD pch_mac l=35.0n w=175.00n m=3
.ends
.subckt CKND2D4BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 net5 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net5 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=4
MM7 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=4
.ends
.subckt CKND2D8BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 net5 VSS nch_mac l=35.0n w=280.0n m=8
MM9 net5 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 ZN A1 VDD VDD pch_mac l=35.0n w=165.00n m=8
MM7 ZN A2 VDD VDD pch_mac l=35.0n w=165.00n m=8
.ends
.subckt CKND3BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=255.00n m=3
MM4 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt CKND4BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=270.0n m=4
MM4 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt CKND6BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt CKND8BWP35 I ZN VDD VSS
MM5 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 ZN I VDD VDD pch_mac l=35.0n w=325.00n m=8
.ends
.subckt CKXOR2D0BWP35 A1 A2 Z VDD VSS
MM9 net38 A1 net22 VSS nch_mac l=35.0n w=140.0n m=1
MM25 net38 net18 net26 VSS nch_mac l=35.0n w=140.0n m=1
MM7 Z net38 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net18 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net22 net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net38 net18 net22 VDD pch_mac l=35.0n w=170.0n m=1
MM24 net38 A1 net26 VDD pch_mac l=35.0n w=170.0n m=1
MM8 Z net38 VDD VDD pch_mac l=35.0n w=210.0n m=1
MM3 net18 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net22 net26 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM4 net26 A2 VDD VDD pch_mac l=35.0n w=210.0n m=1
.ends
.subckt CKXOR2D1BWP35 A1 A2 Z VDD VSS
XMXM1 VSS A1 _SP_48 VSS nch_mac w=0.14u l=0.035u
XMXM2 _SP_53 _SP_51 VSS VSS nch_mac w=0.125u l=0.035u
XMXM3 _SP_52 A1 _SP_53 VSS nch_mac w=0.125u l=0.035u
XMXM4 _SP_51 _SP_48 _SP_52 VSS nch_mac w=0.125u l=0.035u
XMXM5 VSS A2 _SP_51 VSS nch_mac w=0.2u l=0.035u
XMXM6 Z _SP_52 VSS VSS nch_mac w=0.2u l=0.035u
XMXM7 _SP_52 _SP_48 _SP_53 VDD pch_mac w=0.17u l=0.035u
XMXM8 _SP_51 A1 _SP_52 VDD pch_mac w=0.17u l=0.035u
XMXM9 VDD A2 _SP_51 VDD pch_mac w=0.34u l=0.035u
XMXM10 Z _SP_52 VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 VDD A1 _SP_48 VDD pch_mac w=0.17u l=0.035u
XMXM12 _SP_53 _SP_51 VDD VDD pch_mac w=0.24u l=0.035u
.ends
.subckt CKXOR2D2BWP35 A1 A2 Z VDD VSS
MM9 net38 A1 net22 VSS nch_mac l=35.0n w=195.00n m=1
MM25 net38 net18 net26 VSS nch_mac l=35.0n w=195.00n m=1
MM7 Z net38 VSS VSS nch_mac l=35.0n w=200n m=2
MM6 net18 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net22 net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net26 A2 VSS VSS nch_mac l=35.0n w=200n m=1
MM10 net38 net18 net22 VDD pch_mac l=35.0n w=240.0n m=1
MM24 net38 A1 net26 VDD pch_mac l=35.0n w=240.0n m=1
MM8 Z net38 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net18 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net22 net26 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM4 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt CKXOR2D4BWP35 A1 A2 Z VDD VSS
XMXM1 VSS A1 _SP_99 VSS nch_mac w=0.28u l=0.035u
XMXM2 VSS _SP_120 Z VSS nch_mac w=0.2u l=0.035u
XMXM3 Z _SP_120 VSS VSS nch_mac w=0.2u l=0.035u
XMXM4 VSS _SP_120 Z VSS nch_mac w=0.2u l=0.035u
XMXM5 Z _SP_120 VSS VSS nch_mac w=0.2u l=0.035u
XMXM6 VSS A2 _SP_121 VSS nch_mac w=0.17u l=0.035u
XMXM7 _SP_121 A2 VSS VSS nch_mac w=0.17u l=0.035u
XMXM8 VSS A2 _SP_121 VSS nch_mac w=0.17u l=0.035u
XMXM9 _SP_111 _SP_121 VSS VSS nch_mac w=0.21u l=0.035u
XMXM10 _SP_121 _SP_99 _SP_120 VSS nch_mac w=0.185u l=0.035u
XMXM11 _SP_121 _SP_99 _SP_120 VSS nch_mac w=0.185u l=0.035u
XMXM12 _SP_120 A1 _SP_111 VSS nch_mac w=0.275u l=0.035u
XMXM13 _SP_111 A1 _SP_120 VSS nch_mac w=0.275u l=0.035u
XMXM14 _SP_120 _SP_99 _SP_111 VDD pch_mac w=0.34u l=0.035u
XMXM15 _SP_111 _SP_99 _SP_120 VDD pch_mac w=0.34u l=0.035u
XMXM16 _SP_120 A1 _SP_121 VDD pch_mac w=0.135u l=0.035u
XMXM17 _SP_121 A1 _SP_120 VDD pch_mac w=0.135u l=0.035u
XMXM18 VDD A2 _SP_121 VDD pch_mac w=0.34u l=0.035u
XMXM19 _SP_121 A2 VDD VDD pch_mac w=0.34u l=0.035u
XMXM20 VDD A2 _SP_121 VDD pch_mac w=0.34u l=0.035u
XMXM21 _SP_111 _SP_121 VDD VDD pch_mac w=0.34u l=0.035u
XMXM22 _SP_99 A1 VDD VDD pch_mac w=0.16u l=0.035u
XMXM23 VDD _SP_120 Z VDD pch_mac w=0.34u l=0.035u
XMXM24 Z _SP_120 VDD VDD pch_mac w=0.34u l=0.035u
XMXM25 VDD _SP_120 Z VDD pch_mac w=0.34u l=0.035u
XMXM26 Z _SP_120 VDD VDD pch_mac w=0.34u l=0.035u
.ends
.subckt DCAP16BWP35 VDD VSS
MM21 net044 net036 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM1 VDD net044 VDD VDD pch_mac l=360.0n w=215.00n m=1
MM20 net036 net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM26 VDD net044 VDD VDD pch_mac l=360.0n w=215.00n m=1
MM27 VDD net044 VDD VDD pch_mac l=360.0n w=215.00n m=1
.ends
.subckt DCAP32BWP35 VDD VSS
MM21 net044 net036 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 VDD net044 VDD VDD pch_mac l=360.0n w=215.00n m=1
MM29 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM31 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM20 net036 net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net044 VDD VDD pch_mac l=360.0n w=215.00n m=1
MM32 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM30 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
.ends
.subckt DCAP4BWP35 VDD VSS
MM21 net044 net036 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM27 VDD net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM20 net036 net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
.ends
.subckt DCAP64BWP35 VDD VSS
MM21 net044 net036 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM1 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM0 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM11 VDD net044 VDD VDD pch_mac l=500.0n w=215.00n m=1
MM5 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM6 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM9 VDD net044 VDD VDD pch_mac l=500.0n w=215.00n m=1
MM10 VDD net044 VDD VDD pch_mac l=500.0n w=215.00n m=1
MM20 net036 net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM7 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM3 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM4 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
MM8 VDD net044 VDD VDD pch_mac l=500.0n w=215.00n m=1
MM2 VDD net044 VDD VDD pch_mac l=500n w=215.00n m=1
.ends
.subckt DCAP8BWP35 VDD VSS
MM21 net044 net036 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM20 net036 net044 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net044 VDD VDD pch_mac l=250.0n w=215.00n m=1
.ends
.subckt DCCKBD12BWP35 I Z VDD VSS
MM21 net066 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM5 net9 I VSS VSS nch_mac l=35.0n w=275.00n m=4
MM6 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM20 net025 net066 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM26 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt DCCKBD16BWP35 I Z VDD VSS
MM21 net066 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net9 I VSS VSS nch_mac l=35.0n w=275.00n m=5
MM3 VDD net066 VDD VDD pch_mac l=445.00n w=215.00n m=1
MM20 net025 net066 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net066 VDD VDD pch_mac l=445.00n w=215.00n m=1
MM26 VDD net066 VDD VDD pch_mac l=445.00n w=215.00n m=1
MM27 VDD net066 VDD VDD pch_mac l=445.00n w=215.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt DCCKBD20BWP35 I Z VDD VSS
MM21 net061 net037 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=20
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM29 VDD net061 VDD VDD pch_mac l=465.00n w=215.00n m=1
MM31 VDD net061 VDD VDD pch_mac l=465.00n w=215.00n m=1
MM20 net037 net061 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net061 VDD VDD pch_mac l=465.00n w=215.00n m=1
MM32 VDD net061 VDD VDD pch_mac l=465.00n w=215.00n m=1
MM30 VDD net061 VDD VDD pch_mac l=465.00n w=215.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=20
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt DCCKBD4BWP35 I Z VDD VSS
MM21 net038 net021 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net9 I VSS VSS nch_mac l=35.0n w=270.0n m=2
MM27 VDD net038 VDD VDD pch_mac l=120.0n w=215.00n m=1
MM20 net021 net038 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt DCCKBD8BWP35 I Z VDD VSS
MM21 net037 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net9 I VSS VSS nch_mac l=35.0n w=270.0n m=3
MM6 VDD net037 VDD VDD pch_mac l=335.00n w=215.00n m=1
MM3 VDD net037 VDD VDD pch_mac l=335.00n w=215.00n m=1
MM20 net025 net037 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt DCCKND12BWP35 I ZN VDD VSS
MM21 net065 net026 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=12
MM3 VDD net065 VDD VDD pch_mac l=230.0n w=215.00n m=1
MM4 VDD net065 VDD VDD pch_mac l=230.0n w=215.00n m=1
MM20 net026 net065 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM2 VDD net065 VDD VDD pch_mac l=230.0n w=215.00n m=1
MM1 ZN I VDD VDD pch_mac l=35.0n w=310.0n m=12
.ends
.subckt DCCKND16BWP35 I ZN VDD VSS
MM21 net066 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM20 net025 net066 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM26 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM27 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM1 ZN I VDD VDD pch_mac l=35.0n w=305.00n m=16
.ends
.subckt DCCKND20BWP35 I ZN VDD VSS
MM21 net066 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=20
MM3 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM20 net025 net066 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM26 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM27 VDD net066 VDD VDD pch_mac l=410.0n w=215.00n m=1
MM1 ZN I VDD VDD pch_mac l=35.0n w=300n m=20
.ends
.subckt DCCKND4BWP35 I ZN VDD VSS
MM21 net038 net025 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 ZN I VSS VSS nch_mac l=35.0n w=270.0n m=4
MM27 VDD net038 VDD VDD pch_mac l=35.0n w=245.00n m=2
MM20 net025 net038 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM1 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt DCCKND8BWP35 I ZN VDD VSS
MM21 net037 net021 VSS VSS nch_mac l=35.0n w=235.00n m=1
MM0 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=8
MM20 net021 net037 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM25 VDD net037 VDD VDD pch_mac l=390.0n w=215.00n m=1
MM1 ZN I VDD VDD pch_mac l=35.0n w=325.00n m=8
.ends
.subckt DEL025D1BWP35 I Z VDD VSS
MM19 Z net38 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net38 I VSS VSS nch_mac l=35.0n w=120.0n m=1
MM18 Z net38 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net38 I VDD VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt DEL050D1BWP35 I Z VDD VSS
MM6 Z net63 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net63 net67 VSS VSS nch_mac l=90n w=150.0n m=1
MM8 net67 net71 VSS VSS nch_mac l=80n w=150.0n m=1
MM9 net71 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net63 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net63 net67 VDD VDD pch_mac l=90n w=150.0n m=1
MM12 net67 net71 VDD VDD pch_mac l=80n w=150.0n m=1
MM13 net71 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DEL075D1BWP35 I Z VDD VSS
XMXM1 VSS _SP_27 Z VSS nch_mac w=0.28u l=0.035u
XMXM2 VSS _SP_30 _SP_27 VSS nch_mac w=0.12u l=0.16u
XMXM3 VSS _SP_31 _SP_30 VSS nch_mac w=0.12u l=0.16u
XMXM4 VSS I _SP_31 VSS nch_mac w=0.28u l=0.035u
XMXM5 VDD _SP_30 _SP_27 VDD pch_mac w=0.12u l=0.16u
XMXM6 VDD _SP_31 _SP_30 VDD pch_mac w=0.12u l=0.16u
XMXM7 VDD I _SP_31 VDD pch_mac w=0.34u l=0.035u
XMXM8 VDD _SP_27 Z VDD pch_mac w=0.34u l=0.035u
.ends
.subckt DEL100D1BWP35 I Z VDD VSS
XMXM1 VSS _SP_29 _SP_28 VSS nch_mac w=0.12u l=0.21u
XMXM2 VSS _SP_28 _SP_25 VSS nch_mac w=0.15u l=0.21u
XMXM3 VSS _SP_25 Z VSS nch_mac w=0.28u l=0.035u
XMXM4 VSS I _SP_29 VSS nch_mac w=0.28u l=0.035u
XMXM5 VDD _SP_28 _SP_25 VDD pch_mac w=0.12u l=0.21u
XMXM6 VDD _SP_25 Z VDD pch_mac w=0.34u l=0.035u
XMXM7 VDD I _SP_29 VDD pch_mac w=0.34u l=0.035u
XMXM8 VDD _SP_29 _SP_28 VDD pch_mac w=0.15u l=0.21u
.ends
.subckt DEL125D1BWP35 I Z VDD VSS
XMXM1 _SP_43 _SP_46 VSS VSS nch_mac w=0.15u l=0.16u
XMXM2 VSS _SP_52 _SP_46 VSS nch_mac w=0.12u l=0.16u
XMXM3 _SP_51 _SP_49 VSS VSS nch_mac w=0.15u l=0.16u
XMXM4 VSS _SP_43 _SP_49 VSS nch_mac w=0.12u l=0.16u
XMXM5 Z _SP_51 VSS VSS nch_mac w=0.28u l=0.035u
XMXM6 _SP_52 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM7 _SP_52 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM8 _SP_43 _SP_46 VDD VDD pch_mac w=0.15u l=0.16u
XMXM9 VDD _SP_52 _SP_46 VDD pch_mac w=0.15u l=0.16u
XMXM10 Z _SP_51 VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 _SP_51 _SP_49 VDD VDD pch_mac w=0.15u l=0.16u
XMXM12 VDD _SP_43 _SP_49 VDD pch_mac w=0.15u l=0.16u
.ends
.subckt DEL150D1BWP35 I Z VDD VSS
XMXM1 _SP_53 _SP_55 _SP_41 VSS nch_mac w=0.12u l=0.165u
XMXM2 _SP_41 _SP_55 VSS VSS nch_mac w=0.12u l=0.165u
XMXM3 _SP_56 _SP_53 _SP_32 VSS nch_mac w=0.12u l=0.165u
XMXM4 _SP_32 _SP_53 VSS VSS nch_mac w=0.12u l=0.165u
XMXM5 Z _SP_56 VSS VSS nch_mac w=0.28u l=0.035u
XMXM6 _SP_55 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM7 _SP_56 _SP_53 _SP_33 VDD pch_mac w=0.14u l=0.165u
XMXM8 _SP_33 _SP_53 VDD VDD pch_mac w=0.14u l=0.165u
XMXM9 Z _SP_56 VDD VDD pch_mac w=0.34u l=0.035u
XMXM10 _SP_55 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 _SP_53 _SP_55 _SP_38 VDD pch_mac w=0.14u l=0.165u
XMXM12 _SP_38 _SP_55 VDD VDD pch_mac w=0.14u l=0.165u
.ends
.subckt DEL175D1BWP35 I Z VDD VSS
XMXM1 Z _SP_54 VSS VSS nch_mac w=0.28u l=0.035u
XMXM2 _SP_54 _SP_58 _SP_32 VSS nch_mac w=0.12u l=0.18u
XMXM3 _SP_32 _SP_58 VSS VSS nch_mac w=0.12u l=0.18u
XMXM4 _SP_58 _SP_57 _SP_14 VSS nch_mac w=0.12u l=0.18u
XMXM5 _SP_14 _SP_57 VSS VSS nch_mac w=0.12u l=0.18u
XMXM6 _SP_57 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM7 Z _SP_54 VDD VDD pch_mac w=0.34u l=0.035u
XMXM8 _SP_54 _SP_58 _SP_33 VDD pch_mac w=0.14u l=0.18u
XMXM9 _SP_33 _SP_58 VDD VDD pch_mac w=0.14u l=0.18u
XMXM10 _SP_58 _SP_57 _SP_46 VDD pch_mac w=0.13u l=0.18u
XMXM11 _SP_46 _SP_57 VDD VDD pch_mac w=0.13u l=0.18u
XMXM12 _SP_57 I VDD VDD pch_mac w=0.34u l=0.035u
.ends
.subckt DEL1D1BWP35 I Z VDD VSS
XMXM1 _SP_92 _SP_100 _SP_91 VSS nch_mac w=0.1u l=0.285u
XMXM2 _SP_91 _SP_100 VSS VSS nch_mac w=0.1u l=0.285u
XMXM3 _SP_90 _SP_92 _SP_95 VSS nch_mac w=0.1u l=0.285u
XMXM4 _SP_95 _SP_92 VSS VSS nch_mac w=0.1u l=0.285u
XMXM5 _SP_96 _SP_90 _SP_94 VSS nch_mac w=0.1u l=0.285u
XMXM6 _SP_94 _SP_90 VSS VSS nch_mac w=0.1u l=0.285u
XMXM7 _SP_97 _SP_96 _SP_89 VSS nch_mac w=0.1u l=0.285u
XMXM8 _SP_89 _SP_96 VSS VSS nch_mac w=0.1u l=0.285u
XMXM9 Z _SP_97 VSS VSS nch_mac w=0.28u l=0.035u
XMXM10 _SP_100 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM11 _SP_97 _SP_96 _SP_89 VDD pch_mac w=0.1u l=0.285u
XMXM12 _SP_89 _SP_96 VDD VDD pch_mac w=0.1u l=0.285u
XMXM13 Z _SP_97 VDD VDD pch_mac w=0.34u l=0.035u
XMXM14 _SP_100 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM15 _SP_92 _SP_100 _SP_91 VDD pch_mac w=0.13u l=0.285u
XMXM16 _SP_91 _SP_100 VDD VDD pch_mac w=0.13u l=0.285u
XMXM17 _SP_90 _SP_92 _SP_95 VDD pch_mac w=0.1u l=0.285u
XMXM18 _SP_95 _SP_92 VDD VDD pch_mac w=0.1u l=0.285u
XMXM19 _SP_96 _SP_90 _SP_94 VDD pch_mac w=0.1u l=0.285u
XMXM20 _SP_94 _SP_90 VDD VDD pch_mac w=0.1u l=0.285u
.ends
.subckt DEL1P5D1BWP35 I Z VDD VSS
XMXM1 _SP_149 _SP_148 _SP_132 VSS nch_mac w=0.1u l=0.275u
XMXM2 _SP_132 _SP_148 VSS VSS nch_mac w=0.1u l=0.275u
XMXM3 _SP_135 _SP_149 _SP_143 VSS nch_mac w=0.1u l=0.275u
XMXM4 _SP_143 _SP_149 VSS VSS nch_mac w=0.1u l=0.275u
XMXM5 _SP_141 _SP_135 _SP_144 VSS nch_mac w=0.1u l=0.275u
XMXM6 _SP_144 _SP_135 VSS VSS nch_mac w=0.1u l=0.275u
XMXM7 _SP_146 _SP_141 _SP_145 VSS nch_mac w=0.1u l=0.275u
XMXM8 _SP_145 _SP_141 VSS VSS nch_mac w=0.1u l=0.275u
XMXM9 _SP_140 _SP_146 _SP_131 VSS nch_mac w=0.1u l=0.275u
XMXM10 _SP_131 _SP_146 VSS VSS nch_mac w=0.1u l=0.275u
XMXM11 _SP_138 _SP_140 _SP_133 VSS nch_mac w=0.1u l=0.275u
XMXM12 _SP_133 _SP_140 VSS VSS nch_mac w=0.1u l=0.275u
XMXM13 Z _SP_138 VSS VSS nch_mac w=0.28u l=0.035u
XMXM14 _SP_148 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM15 _SP_146 _SP_141 _SP_145 VDD pch_mac w=0.1u l=0.275u
XMXM16 _SP_145 _SP_141 VDD VDD pch_mac w=0.1u l=0.275u
XMXM17 _SP_140 _SP_146 _SP_131 VDD pch_mac w=0.12u l=0.275u
XMXM18 _SP_131 _SP_146 VDD VDD pch_mac w=0.12u l=0.275u
XMXM19 Z _SP_138 VDD VDD pch_mac w=0.34u l=0.035u
XMXM20 _SP_148 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM21 _SP_149 _SP_148 _SP_132 VDD pch_mac w=0.12u l=0.275u
XMXM22 _SP_132 _SP_148 VDD VDD pch_mac w=0.12u l=0.275u
XMXM23 _SP_135 _SP_149 _SP_143 VDD pch_mac w=0.1u l=0.275u
XMXM24 _SP_143 _SP_149 VDD VDD pch_mac w=0.1u l=0.275u
XMXM25 _SP_141 _SP_135 _SP_144 VDD pch_mac w=0.12u l=0.275u
XMXM26 _SP_144 _SP_135 VDD VDD pch_mac w=0.12u l=0.275u
XMXM27 _SP_138 _SP_140 _SP_133 VDD pch_mac w=0.1u l=0.275u
XMXM28 _SP_133 _SP_140 VDD VDD pch_mac w=0.1u l=0.275u
.ends
.subckt DEL200D1BWP35 I Z VDD VSS
XMXM1 _SP_58 _SP_63 _SP_61 VSS nch_mac w=0.15u l=0.19u
XMXM2 _SP_61 _SP_63 VSS VSS nch_mac w=0.15u l=0.19u
XMXM3 _SP_62 _SP_58 _SP_36 VSS nch_mac w=0.22u l=0.19u
XMXM4 _SP_36 _SP_58 VSS VSS nch_mac w=0.22u l=0.19u
XMXM5 Z _SP_62 VSS VSS nch_mac w=0.28u l=0.035u
XMXM6 _SP_63 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM7 _SP_62 _SP_58 _SP_37 VDD pch_mac w=0.19u l=0.19u
XMXM8 _SP_37 _SP_58 VDD VDD pch_mac w=0.19u l=0.19u
XMXM9 Z _SP_62 VDD VDD pch_mac w=0.34u l=0.035u
XMXM10 _SP_63 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 _SP_58 _SP_63 _SP_61 VDD pch_mac w=0.16u l=0.19u
XMXM12 _SP_61 _SP_63 VDD VDD pch_mac w=0.16u l=0.19u
.ends
.subckt DEL225D1BWP35 I Z VDD VSS
XMXM1 _SP_54 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM2 Z _SP_49 VSS VSS nch_mac w=0.28u l=0.035u
XMXM3 _SP_52 _SP_54 _SP_55 VSS nch_mac w=0.12u l=0.21u
XMXM4 _SP_55 _SP_54 VSS VSS nch_mac w=0.12u l=0.21u
XMXM5 _SP_49 _SP_52 _SP_29 VSS nch_mac w=0.12u l=0.21u
XMXM6 _SP_29 _SP_52 VSS VSS nch_mac w=0.12u l=0.21u
XMXM7 _SP_49 _SP_52 _SP_30 VDD pch_mac w=0.12u l=0.21u
XMXM8 _SP_30 _SP_52 VDD VDD pch_mac w=0.12u l=0.21u
XMXM9 Z _SP_49 VDD VDD pch_mac w=0.34u l=0.035u
XMXM10 _SP_54 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 _SP_52 _SP_54 _SP_55 VDD pch_mac w=0.135u l=0.21u
XMXM12 _SP_55 _SP_54 VDD VDD pch_mac w=0.135u l=0.21u
.ends
.subckt DEL250D1BWP35 I Z VDD VSS
XMXM1 _SP_60 _SP_66 VSS VSS nch_mac w=0.12u l=0.205u
XMXM2 VSS _SP_67 _SP_66 VSS nch_mac w=0.12u l=0.205u
XMXM3 _SP_65 _SP_68 VSS VSS nch_mac w=0.12u l=0.205u
XMXM4 VSS _SP_60 _SP_68 VSS nch_mac w=0.12u l=0.205u
XMXM5 _SP_64 _SP_61 VSS VSS nch_mac w=0.12u l=0.205u
XMXM6 VSS _SP_65 _SP_61 VSS nch_mac w=0.12u l=0.205u
XMXM7 Z _SP_64 VSS VSS nch_mac w=0.28u l=0.035u
XMXM8 _SP_67 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM9 Z _SP_64 VDD VDD pch_mac w=0.34u l=0.035u
XMXM10 _SP_67 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM11 _SP_65 _SP_68 VDD VDD pch_mac w=0.15u l=0.205u
XMXM12 VDD _SP_60 _SP_68 VDD pch_mac w=0.15u l=0.205u
XMXM13 _SP_64 _SP_61 VDD VDD pch_mac w=0.15u l=0.205u
XMXM14 VDD _SP_65 _SP_61 VDD pch_mac w=0.15u l=0.205u
XMXM15 _SP_60 _SP_66 VDD VDD pch_mac w=0.12u l=0.205u
XMXM16 VDD _SP_67 _SP_66 VDD pch_mac w=0.12u l=0.205u
.ends
.subckt DEL2D1BWP35 I Z VDD VSS
XMXM1 Z _SP_149 VSS VSS nch_mac w=0.28u l=0.035u
XMXM2 _SP_149 _SP_143 _SP_142 VSS nch_mac w=0.1u l=0.32u
XMXM3 _SP_142 _SP_143 VSS VSS nch_mac w=0.1u l=0.32u
XMXM4 _SP_143 _SP_148 _SP_131 VSS nch_mac w=0.1u l=0.32u
XMXM5 _SP_131 _SP_148 VSS VSS nch_mac w=0.1u l=0.32u
XMXM6 _SP_148 _SP_134 _SP_140 VSS nch_mac w=0.1u l=0.32u
XMXM7 _SP_140 _SP_134 VSS VSS nch_mac w=0.1u l=0.32u
XMXM8 _SP_134 _SP_132 _SP_146 VSS nch_mac w=0.1u l=0.32u
XMXM9 _SP_146 _SP_132 VSS VSS nch_mac w=0.1u l=0.32u
XMXM10 _SP_132 _SP_147 _SP_135 VSS nch_mac w=0.1u l=0.32u
XMXM11 _SP_135 _SP_147 VSS VSS nch_mac w=0.1u l=0.32u
XMXM12 _SP_147 _SP_141 _SP_133 VSS nch_mac w=0.1u l=0.32u
XMXM13 _SP_133 _SP_141 VSS VSS nch_mac w=0.1u l=0.32u
XMXM14 _SP_141 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM15 Z _SP_149 VDD VDD pch_mac w=0.34u l=0.035u
XMXM16 _SP_149 _SP_143 _SP_142 VDD pch_mac w=0.1u l=0.32u
XMXM17 _SP_142 _SP_143 VDD VDD pch_mac w=0.1u l=0.32u
XMXM18 _SP_143 _SP_148 _SP_131 VDD pch_mac w=0.1u l=0.32u
XMXM19 _SP_131 _SP_148 VDD VDD pch_mac w=0.1u l=0.32u
XMXM20 _SP_148 _SP_134 _SP_140 VDD pch_mac w=0.1u l=0.32u
XMXM21 _SP_140 _SP_134 VDD VDD pch_mac w=0.1u l=0.32u
XMXM22 _SP_134 _SP_132 _SP_146 VDD pch_mac w=0.1u l=0.32u
XMXM23 _SP_146 _SP_132 VDD VDD pch_mac w=0.1u l=0.32u
XMXM24 _SP_132 _SP_147 _SP_135 VDD pch_mac w=0.1u l=0.32u
XMXM25 _SP_135 _SP_147 VDD VDD pch_mac w=0.1u l=0.32u
XMXM26 _SP_147 _SP_141 _SP_133 VDD pch_mac w=0.1u l=0.32u
XMXM27 _SP_133 _SP_141 VDD VDD pch_mac w=0.1u l=0.32u
XMXM28 _SP_141 I VDD VDD pch_mac w=0.34u l=0.035u
.ends
.subckt DEL500D1BWP35 I Z VDD VSS
XMXM1 _SP_101 _SP_104 _SP_98 VSS nch_mac w=0.185u l=0.2u
XMXM2 _SP_98 _SP_104 VSS VSS nch_mac w=0.185u l=0.2u
XMXM3 _SP_103 _SP_101 _SP_102 VSS nch_mac w=0.12u l=0.2u
XMXM4 _SP_102 _SP_101 VSS VSS nch_mac w=0.12u l=0.2u
XMXM5 _SP_95 _SP_103 _SP_96 VSS nch_mac w=0.12u l=0.2u
XMXM6 _SP_96 _SP_103 VSS VSS nch_mac w=0.12u l=0.2u
XMXM7 _SP_105 _SP_95 _SP_100 VSS nch_mac w=0.12u l=0.2u
XMXM8 _SP_100 _SP_95 VSS VSS nch_mac w=0.12u l=0.2u
XMXM9 Z _SP_105 VSS VSS nch_mac w=0.28u l=0.035u
XMXM10 _SP_104 I VSS VSS nch_mac w=0.28u l=0.035u
XMXM11 _SP_103 _SP_101 _SP_102 VDD pch_mac w=0.12u l=0.2u
XMXM12 _SP_102 _SP_101 VDD VDD pch_mac w=0.12u l=0.2u
XMXM13 _SP_95 _SP_103 _SP_96 VDD pch_mac w=0.12u l=0.2u
XMXM14 _SP_96 _SP_103 VDD VDD pch_mac w=0.12u l=0.2u
XMXM15 Z _SP_105 VDD VDD pch_mac w=0.34u l=0.035u
XMXM16 _SP_104 I VDD VDD pch_mac w=0.34u l=0.035u
XMXM17 _SP_101 _SP_104 _SP_98 VDD pch_mac w=0.22u l=0.2u
XMXM18 _SP_98 _SP_104 VDD VDD pch_mac w=0.22u l=0.2u
XMXM19 _SP_105 _SP_95 _SP_100 VDD pch_mac w=0.12u l=0.2u
XMXM20 _SP_100 _SP_95 VDD VDD pch_mac w=0.12u l=0.2u
.ends
.subckt DFCND1BWP35 D CP CDN Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM3 net0149 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM4 net0149 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0149 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFCND2BWP35 D CP CDN Q QN VDD VSS
MM2 qf_x qf net0165 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0165 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net0170 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0170 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0170 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFCND4BWP35 D CP CDN Q QN VDD VSS
MM2 qf_x qf net0165 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0165 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net0170 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0170 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM4 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0170 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFCNQD1BWP35 D CP CDN Q VDD VSS
MM4 qf clkb net0152 VSS nch_mac l=35.0n w=165.00n m=1
MM5 net0152 qf_x VSS VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=260.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM3 qf clkbb net093 VDD pch_mac l=35.0n w=295.00n m=1
MM2 net093 qf_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM60 net0138 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0138 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0138 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFCNQD2BWP35 D CP CDN Q VDD VSS
MM6 qf_x qf net0145 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net0145 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf clkb net0152 VSS nch_mac l=35.0n w=250.0n m=1
MM5 net0152 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM3 qf clkbb net097 VDD pch_mac l=35.0n w=295.00n m=1
MM2 net097 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM60 net0143 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0143 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0143 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFCNQD4BWP35 D CP CDN Q VDD VSS
MM6 qf_x qf net0145 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net0145 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf clkb net0152 VSS nch_mac l=35.0n w=250.0n m=1
MM5 net0152 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM8 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf clkbb net0101 VDD pch_mac l=35.0n w=295.00n m=1
MM2 net0101 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM60 net0147 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0147 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM10 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0147 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt DFCSND1BWP35 D CP CDN SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0183 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0183 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0165 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0165 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0165 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFCSND2BWP35 D CP CDN SDN Q QN VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0198 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0198 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0172 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0172 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFCSND4BWP35 D CP CDN SDN Q QN VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0201 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0201 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0172 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0172 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFCSNQD1BWP35 D CP CDN SDN Q VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0175 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0175 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0155 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0155 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0155 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFCSNQD2BWP35 D CP CDN SDN Q VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0187 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0187 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0161 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0161 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0161 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFCSNQD4BWP35 D CP CDN SDN Q VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0187 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=250.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0187 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0161 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0161 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0161 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFD1BWP35 D CP Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=175.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=175.00n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM61 net092 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 mq_x clkb net092 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFD2BWP35 D CP Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0132 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0132 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFD4BWP35 D CP Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=280.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM0 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net0132 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=240.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0132 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=240.0n m=1
.ends
.subckt DFKCND1BWP35 D CP CN Q QN VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=135.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=135.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=175.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM60 net0143 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net090 D VDD VDD pch_mac l=35.0n w=175.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0143 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCND2BWP35 D CP CN Q QN VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=135.00n m=1
MM4 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=135.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=175.00n m=1
MM3 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=175.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0143 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net090 D VDD VDD pch_mac l=35.0n w=175.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0143 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCND4BWP35 D CP CN Q QN VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=270.0n m=1
MM4 net172 qf_x VSS VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=145.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=145.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=270.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=270.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=145.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=145.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=145.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=270.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=145.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=145.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=330.0n m=1
MM3 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=185.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=330.0n m=4
MM60 net0143 mq VDD VDD pch_mac l=35.0n w=185.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=330.0n m=2
MM44 net090 D VDD VDD pch_mac l=35.0n w=185.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=330.0n m=4
MM79 mq_x clkb net0143 VDD pch_mac l=35.0n w=185.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFKCNQD1BWP35 D CP CN Q VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=250.0n m=1
MM5 qf clkb net0147 VSS nch_mac l=35.0n w=165.00n m=1
MM6 net0147 qf_x VSS VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=165.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=165.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=250.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=165.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=165.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=250.0n m=1
MM4 qf clkbb net089 VDD pch_mac l=35.0n w=185.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=175.00n m=1
MM3 net089 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=175.00n m=1
MM60 net0128 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net090 D VDD VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0128 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCNQD2BWP35 D CP CN Q VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=250.0n m=1
MM5 qf clkb net0147 VSS nch_mac l=35.0n w=165.00n m=1
MM6 net0147 qf_x VSS VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=165.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=165.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=250.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=165.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=250.0n m=1
MM4 qf clkbb net088 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=175.00n m=1
MM3 net088 qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=175.00n m=1
MM60 net0128 mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 D VDD VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0128 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCNQD4BWP35 D CP CN Q VDD VSS
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=270.0n m=1
MM5 qf clkb net0147 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net0147 qf_x VSS VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=145.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=270.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=145.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=145.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=145.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=270.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=145.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=145.00n m=1
MM4 qf clkbb net088 VDD pch_mac l=35.0n w=185.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=330.0n m=1
MM3 net088 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=185.00n m=1
MM60 net0128 mq VDD VDD pch_mac l=35.0n w=185.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=330.0n m=2
MM44 net090 D VDD VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=330.0n m=4
MM79 mq_x clkb net0128 VDD pch_mac l=35.0n w=185.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFKCSND1BWP35 D CP CN SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net212 net0173 net0146 VSS nch_mac l=35.0n w=100n m=1
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=215.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM60 net0163 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net090 D net0144 VDD pch_mac l=35.0n w=215.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0163 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCSND2BWP35 D CP CN SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net212 net0173 net0146 VSS nch_mac l=35.0n w=100n m=1
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM1 net090 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=215.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0163 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net090 D net0144 VDD pch_mac l=35.0n w=215.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0163 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKCSND4BWP35 D CP CN SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=275.00n m=1
MM5 net212 net0173 net0146 VSS nch_mac l=35.0n w=130.0n m=1
MM2 net0146 CN VSS VSS nch_mac l=35.0n w=275.00n m=1
MM8 qf_x qf VSS VSS nch_mac l=35.0n w=270.0n m=2
MM10 net172 qf_x VSS VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=145.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=145.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=270.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=270.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=145.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=145.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=145.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=145.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D net0146 VSS nch_mac l=35.0n w=275.00n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=260.0n m=1
MM7 qf_x qf VDD VDD pch_mac l=35.0n w=330.0n m=2
MM1 net090 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM9 net172 qf_x VDD VDD pch_mac l=35.0n w=200n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=330.0n m=4
MM60 net0163 mq VDD VDD pch_mac l=35.0n w=200n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=200n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 D net0144 VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=200n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=330.0n m=4
MM79 mq_x clkb net0163 VDD pch_mac l=35.0n w=200n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=200n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFKSND1BWP35 D CP SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net212 net0173 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net212 VDD pch_mac l=35.0n w=215.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM60 net0153 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net212 D net0144 VDD pch_mac l=35.0n w=340.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0153 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKSND2BWP35 D CP SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net212 net0173 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net172 qf_x VSS VSS nch_mac l=35.0n w=135.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=135.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=135.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=135.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=135.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=135.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=135.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net172 qf_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkbb net212 VDD pch_mac l=35.0n w=215.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0153 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=185.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=185.00n m=1
MM44 net212 D net0144 VDD pch_mac l=35.0n w=340.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=185.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0153 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=185.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFKSND4BWP35 D CP SN Q QN VDD VSS
MM4 net0173 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net212 net0173 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=145.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=145.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=270.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=270.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=145.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=145.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=145.00n m=1
MM8 qf_x qf VSS VSS nch_mac l=35.0n w=270.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=145.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0173 SN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net0144 net0173 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net212 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=330.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=200n m=1
MM60 net0153 mq VDD VDD pch_mac l=35.0n w=200n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=200n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 qf_x qf VDD VDD pch_mac l=35.0n w=330.0n m=2
MM44 net212 D net0144 VDD pch_mac l=35.0n w=340.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=200n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=330.0n m=4
MM79 mq_x clkb net0153 VDD pch_mac l=35.0n w=200n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=200n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFMD1BWP35 DA DB SA CP Q QN VDD VSS
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM2 net0146 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=170.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0146 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=210.0n m=1
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=210.0n m=1
MM44 net090 SA net0146 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=250.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt DFMD2BWP35 DA DB SA CP Q QN VDD VSS
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM2 net0231 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0176 net0231 VSS nch_mac l=35.0n w=170.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0231 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 SA net0231 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=250.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt DFMD4BWP35 DA DB SA CP Q QN VDD VSS
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM2 net0237 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
MM15 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0176 net0237 VSS nch_mac l=35.0n w=170.0n m=1
MM0 qf_x qf VDD VDD pch_mac l=35.0n w=240.0n m=1
MM10 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0237 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM14 net172 qf_x VDD VDD pch_mac l=35.0n w=240.0n m=1
MM12 clkbb clkb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 SA net0237 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=250.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
.ends
.subckt DFMQD1BWP35 DA DB SA CP Q VDD VSS
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM12 qf clkb net0177 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net0177 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM2 net0146 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=140.0n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=250.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=170.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0146 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=180.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 SA net0146 VDD pch_mac l=35.0n w=270.0n m=1
MM10 net0116 qf_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=180.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=180.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM11 qf clkbb net0116 VDD pch_mac l=35.0n w=180.0n m=1
.ends
.subckt DFMQD2BWP35 DA DB SA CP Q VDD VSS
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM12 qf clkb net0177 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net0177 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM2 net0146 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=140.0n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=250.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=170.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0146 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=180.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 SA net0146 VDD pch_mac l=35.0n w=270.0n m=1
MM10 net0116 qf_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=180.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=180.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM11 qf clkbb net0116 VDD pch_mac l=35.0n w=180.0n m=1
.ends
.subckt DFMQD4BWP35 DA DB SA CP Q VDD VSS
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net0184 DA VSS VSS nch_mac l=35.0n w=170.0n m=1
MM4 net0176 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 SA net0184 VSS nch_mac l=35.0n w=170.0n m=1
MM18 net0181 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net0225 DB VSS VSS nch_mac l=35.0n w=170.0n m=1
MM17 qf clkb net0181 VSS nch_mac l=35.0n w=140.0n m=1
MM13 clkbb clkb VSS VSS nch_mac l=35.0n w=250.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=140.0n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0176 net0225 VSS nch_mac l=35.0n w=170.0n m=1
MM10 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM7 net0119 DA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 SA VDD VDD pch_mac l=35.0n w=270.0n m=1
MM6 net0225 DB VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0119 VDD pch_mac l=35.0n w=270.0n m=1
MM15 net0120 qf_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM12 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM16 qf clkbb net0120 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=240.0n m=1
MM60 net0171 mq VDD VDD pch_mac l=35.0n w=180.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=180.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 SA net0225 VDD pch_mac l=35.0n w=270.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0171 VDD pch_mac l=35.0n w=180.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=180.0n m=1
.ends
.subckt DFNCND1BWP35 D CPN CDN Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM3 net0149 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM4 net0149 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkbb net0149 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFNCND2BWP35 D CPN CDN Q QN VDD VSS
MM2 qf_x qf net0165 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0165 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net0170 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0170 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkbb net0170 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFNCND4BWP35 D CPN CDN Q QN VDD VSS
MM2 qf_x qf net0165 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0165 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net0170 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net0170 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM5 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=295.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net0170 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM8 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFNCSND1BWP35 D CPN CDN SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0183 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0183 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0165 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0165 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkbb net0165 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFNCSND2BWP35 D CPN CDN SDN Q QN VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0198 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0198 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0172 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkbb net0172 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFNCSND4BWP35 D CPN CDN SDN Q QN VDD VSS
MM4 qf_x qf net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0178 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0201 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=250.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=250.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq net184 VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net208 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0201 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=185.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=295.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM60 net0172 CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM61 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=295.00n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=115.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net0172 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFND1BWP35 D CPN Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=175.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 mq_x clkb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=175.00n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM61 net092 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 mq_x clkbb net092 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFND2BWP35 D CPN Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0132 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkbb net0132 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFND4BWP35 D CPN Q QN VDD VSS
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=280.0n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net0132 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=240.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net0132 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=240.0n m=1
.ends
.subckt DFNSND1BWP35 D CPN SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=140.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkbb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFNSND2BWP35 D CPN SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=140.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkbb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFNSND4BWP35 D CPN SDN Q QN VDD VSS
MM5 clkb CPN VSS VSS nch_mac l=35.0n w=200n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkbb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq VSS VSS nch_mac l=35.0n w=150.0n m=1
MM64 mq_x clkb net176 VSS nch_mac l=35.0n w=150.0n m=1
MM46 mq_x clkbb net212 VSS nch_mac l=35.0n w=150.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=200n m=1
MM4 clkb CPN VDD VDD pch_mac l=35.0n w=200n m=1
MM45 mq_x clkb net103 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=150.0n m=1
MM6 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net0144 VDD pch_mac l=35.0n w=150.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFQD1BWP35 D CP Q VDD VSS
MM2 qf clkb net0136 VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=175.00n m=1
MM3 net0136 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=175.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM0 net086 qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM1 qf clkbb net086 VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0118 mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0118 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFQD2BWP35 D CP Q VDD VSS
MM2 qf clkb net0136 VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=175.00n m=1
MM3 net0136 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=175.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM0 net086 qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM1 qf clkbb net086 VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0118 mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0118 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt DFQD4BWP35 D CP Q VDD VSS
MM2 qf clkb net0136 VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=175.00n m=1
MM3 net0136 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=175.00n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM0 net086 qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM1 qf clkbb net086 VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0118 mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0118 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt DFSND1BWP35 D CP SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFSND2BWP35 D CP SDN Q QN VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFSND4BWP35 D CP SDN Q QN VDD VSS
MM5 clkb CP VSS VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=195.00n m=1
MM4 clkb CP VDD VDD pch_mac l=35.0n w=290.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=190.0n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=190.0n m=1
MM6 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=290.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=190.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFSNQD1BWP35 D CP SDN Q VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=200n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFSNQD2BWP35 D CP SDN Q VDD VSS
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net176 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=200n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=200n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=200n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt DFSNQD4BWP35 D CP SDN Q VDD VSS
MM5 clkb CP VSS VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0176 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0162 mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM73 net172 SDN net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=225.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=225.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net176 mq VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq SDN net0162 VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=195.00n m=1
MM4 clkb CP VDD VDD pch_mac l=35.0n w=290.0n m=1
MM45 mq_x clkbb net103 VDD pch_mac l=35.0n w=170.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net172 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM61 net0144 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net103 D VDD VDD pch_mac l=35.0n w=290.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=110.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0144 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt EDFCND1BWP35 D E CP CDN Q QN VDD VSS
MM11 net0211 CDN VSS VSS nch_mac l=35.0n w=175.00n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=175.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0211 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=255.00n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=255.00n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFCND2BWP35 D E CP CDN Q QN VDD VSS
MM14 net0215 CDN VSS VSS nch_mac l=35.0n w=195.00n m=1
MM15 qf_x qf net0215 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0209 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=195.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=195.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0209 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=260.0n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFCND4BWP35 D E CP CDN Q QN VDD VSS
MM22 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 qf_x qf net0213 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0221 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net0213 CDN VSS VSS nch_mac l=35.0n w=195.00n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM17 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM19 net172 qf_x VSS VSS nch_mac l=35.0n w=195.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=195.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0221 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=260.0n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM16 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM18 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM14 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt EDFCNQD1BWP35 D E CP CDN Q VDD VSS
MM11 net0196 CDN VSS VSS nch_mac l=35.0n w=175.00n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0196 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=255.00n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=255.00n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFCNQD2BWP35 D E CP CDN Q VDD VSS
MM15 qf_x qf net0204 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0196 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net0204 CDN VSS VSS nch_mac l=35.0n w=195.00n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=195.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=195.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0196 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=260.0n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFCNQD4BWP35 D E CP CDN Q VDD VSS
MM21 qf_x qf net0213 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0221 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net0213 CDN VSS VSS nch_mac l=35.0n w=195.00n m=1
MM13 net0201 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM17 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM19 net172 qf_x VSS VSS nch_mac l=35.0n w=195.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=195.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq net0201 VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM76 qf_x qf net0221 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=260.0n m=1
MM12 net0199 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM16 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM18 net172 qf_x VDD VDD pch_mac l=35.0n w=260.0n m=1
MM60 net0199 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM14 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0199 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt EDFD1BWP35 D E CP Q QN VDD VSS
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=320.0n m=1
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=280.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=280.0n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=280.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFD2BWP35 D E CP Q QN VDD VSS
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM16 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=275.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM15 net172 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFD4BWP35 D E CP Q QN VDD VSS
MM16 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM18 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM20 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=275.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM15 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM19 net172 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM17 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt EDFKCND1BWP35 D E CP CN Q QN VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=195.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=195.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt EDFKCND2BWP35 D E CP CN Q QN VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM18 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=195.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt EDFKCND4BWP35 D E CP CN Q QN VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM20 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM18 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN net172 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM70 QN net172 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM19 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=195.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt EDFKCNQD1BWP35 D E CP CN Q VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=175.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt EDFKCNQD2BWP35 D E CP CN Q VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM18 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=195.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt EDFKCNQD4BWP35 D E CP CN Q VDD VSS
MM14 net0195 CN VSS VSS nch_mac l=35.0n w=260.0n m=1
MM8 net0184 E net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM4 net0199 E VSS VSS nch_mac l=35.0n w=260.0n m=1
MM20 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net212 D net0184 VSS nch_mac l=35.0n w=195.00n m=1
MM2 net0146 net172 net0195 VSS nch_mac l=35.0n w=195.00n m=1
MM18 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=195.00n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 net0199 net0146 VSS nch_mac l=35.0n w=195.00n m=1
MM13 net090 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net0119 net0199 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM3 net0199 E VDD VDD pch_mac l=35.0n w=100n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM1 net090 D net0119 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net172 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net0181 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM19 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=195.00n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0181 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt EDFQD1BWP35 D E CP Q VDD VSS
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=270.0n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=270.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=320.0n m=1
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=280.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=280.0n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=280.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFQD2BWP35 D E CP Q VDD VSS
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM73 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=275.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM74 net172 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt EDFQD4BWP35 D E CP Q VDD VSS
MM16 clkb CP VSS VSS nch_mac l=35.0n w=270.0n m=1
MM18 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net0184 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM4 net0176 E VSS VSS nch_mac l=35.0n w=255.00n m=1
MM9 net212 E net0184 VSS nch_mac l=35.0n w=175.00n m=1
MM2 net0146 net172 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM20 net172 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=275.00n m=1
MM67 net172 clkb qf VSS nch_mac l=35.0n w=275.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM64 mq_x clkbb net176 VSS nch_mac l=35.0n w=100n m=1
MM66 net176 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=170.0n m=1
MM14 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net212 net0176 net0146 VSS nch_mac l=35.0n w=175.00n m=1
MM15 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM7 net0184 D VDD VDD pch_mac l=35.0n w=270.0n m=1
MM3 net0176 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net0144 net172 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net090 net0176 net0184 VDD pch_mac l=35.0n w=270.0n m=1
MM19 net172 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM45 mq_x clkbb net090 VDD pch_mac l=35.0n w=265.00n m=1
MM60 net0173 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM17 clkbb clkb VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net090 E net0144 VDD pch_mac l=35.0n w=270.0n m=1
MM68 net172 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net0173 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt FA1D0BWP35 A B CI S CO VDD VSS
MM3 net93 net97 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net73 net77 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net119 B net97 VSS nch_mac l=35.0n w=200n m=1
MM6 net101 B VSS VSS nch_mac l=35.0n w=255.00n m=1
MM8 net63 net119 VSS VSS nch_mac l=35.0n w=255.00n m=1
MM14 net77 CI VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net85 net63 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net85 net119 net73 VSS nch_mac l=35.0n w=280.0n m=1
MM62 net119 net101 net93 VSS nch_mac l=35.0n w=200n m=1
MM19 net61 net119 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net97 A VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 CO net61 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net61 net63 net101 VSS nch_mac l=35.0n w=280.0n m=1
MM71 S net85 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net93 net97 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net73 net77 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net119 net101 net97 VDD pch_mac l=35.0n w=200n m=1
MM24 CO net61 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net101 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net63 net119 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net77 CI VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net85 net119 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM13 net85 net63 net73 VDD pch_mac l=35.0n w=250.0n m=1
MM59 net119 B net93 VDD pch_mac l=35.0n w=200n m=1
MM1 net97 A VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net61 net63 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM23 net61 net119 net101 VDD pch_mac l=35.0n w=250.0n m=1
MM72 S net85 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt FA1D1BWP35 A B CI S CO VDD VSS
MM3 net93 net97 VSS VSS nch_mac l=35.0n w=265.00n m=2
MM16 net73 net77 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net119 B net97 VSS nch_mac l=35.0n w=200n m=1
MM6 net101 B VSS VSS nch_mac l=35.0n w=195.00n m=1
MM8 net63 net119 VSS VSS nch_mac l=35.0n w=195.00n m=1
MM14 net77 CI VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net85 net63 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net85 net119 net73 VSS nch_mac l=35.0n w=280.0n m=1
MM62 net119 net101 net93 VSS nch_mac l=35.0n w=200n m=1
MM19 net61 net119 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net97 A VSS VSS nch_mac l=35.0n w=265.00n m=2
MM18 CO net61 VSS VSS nch_mac l=35.0n w=265.00n m=1
MM20 net61 net63 net101 VSS nch_mac l=35.0n w=280.0n m=1
MM71 S net85 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net77 CI VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net93 net97 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 net73 net77 VDD VDD pch_mac l=35.0n w=300n m=1
MM5 net119 net101 net97 VDD pch_mac l=35.0n w=200n m=1
MM21 CO net61 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net101 B VDD VDD pch_mac l=35.0n w=295.00n m=1
MM9 net63 net119 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM15 net77 CI VDD VDD pch_mac l=35.0n w=300n m=1
MM12 net85 net119 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM13 net85 net63 net73 VDD pch_mac l=35.0n w=250.0n m=1
MM59 net119 B net93 VDD pch_mac l=35.0n w=200n m=1
MM1 net97 A VDD VDD pch_mac l=35.0n w=340.0n m=2
MM22 net61 net63 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM23 net61 net119 net101 VDD pch_mac l=35.0n w=250.0n m=1
MM72 S net85 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt FA1D2BWP35 A B CI S CO VDD VSS
MM3 net93 net97 VSS VSS nch_mac l=35.0n w=265.00n m=2
MM16 net73 net77 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net119 B net97 VSS nch_mac l=35.0n w=200n m=1
MM6 net101 B VSS VSS nch_mac l=35.0n w=195.00n m=1
MM8 net63 net119 VSS VSS nch_mac l=35.0n w=195.00n m=1
MM14 net77 CI VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net85 net63 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net85 net119 net73 VSS nch_mac l=35.0n w=280.0n m=1
MM62 net119 net101 net93 VSS nch_mac l=35.0n w=200n m=1
MM19 net61 net119 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net97 A VSS VSS nch_mac l=35.0n w=265.00n m=2
MM18 CO net61 VSS VSS nch_mac l=35.0n w=265.00n m=2
MM20 net61 net63 net101 VSS nch_mac l=35.0n w=280.0n m=1
MM71 S net85 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM24 net77 CI VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net93 net97 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 net73 net77 VDD VDD pch_mac l=35.0n w=300n m=1
MM5 net119 net101 net97 VDD pch_mac l=35.0n w=200n m=1
MM21 CO net61 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net101 B VDD VDD pch_mac l=35.0n w=295.00n m=1
MM9 net63 net119 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM15 net77 CI VDD VDD pch_mac l=35.0n w=300n m=1
MM12 net85 net119 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM13 net85 net63 net73 VDD pch_mac l=35.0n w=250.0n m=1
MM59 net119 B net93 VDD pch_mac l=35.0n w=200n m=1
MM1 net97 A VDD VDD pch_mac l=35.0n w=340.0n m=2
MM22 net61 net63 net77 VDD pch_mac l=35.0n w=250.0n m=1
MM23 net61 net119 net101 VDD pch_mac l=35.0n w=250.0n m=1
MM72 S net85 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt FA1D4BWP35 A B CI S CO VDD VSS
MM3 net93 net97 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 net73 net77 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net119 B net97 VSS nch_mac l=35.0n w=170.0n m=1
MM6 net101 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net63 net119 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net77 CI VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net85 net63 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net85 net119 net73 VSS nch_mac l=35.0n w=280.0n m=1
MM62 net119 net101 net93 VSS nch_mac l=35.0n w=245.00n m=1
MM19 net61 net119 net77 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net97 A VSS VSS nch_mac l=35.0n w=280.0n m=3
MM18 CO net61 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM20 net61 net63 net101 VSS nch_mac l=35.0n w=280.0n m=1
MM71 S net85 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net93 net97 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 net73 net77 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM5 net119 net101 net97 VDD pch_mac l=35.0n w=340.0n m=1
MM21 CO net61 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net101 B VDD VDD pch_mac l=35.0n w=310.0n m=2
MM9 net63 net119 VDD VDD pch_mac l=35.0n w=310.0n m=1
MM15 net77 CI VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 net85 net119 net77 VDD pch_mac l=35.0n w=255.00n m=1
MM13 net85 net63 net73 VDD pch_mac l=35.0n w=255.00n m=1
MM59 net119 B net93 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net97 A VDD VDD pch_mac l=35.0n w=340.0n m=3
MM22 net61 net63 net77 VDD pch_mac l=35.0n w=255.00n m=1
MM23 net61 net119 net101 VDD pch_mac l=35.0n w=255.00n m=1
MM72 S net85 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt GAN2D1BWP35 A1 A2 Z VDD VSS
MM1 VSS net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 VDD net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GAN2D2BWP35 A1 A2 Z VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net26 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GAOI21D1BWP35 A1 A2 B ZN VDD VSS
MM5 VSS B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net94 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net94 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 VDD B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net89 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A2 net89 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net89 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GAOI21D2BWP35 A1 A2 B ZN VDD VSS
MM5 ZN A1 net027 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net027 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GAOI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GBUFFD1BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GBUFFD2BWP35 I Z VDD VSS
MM26 VSS I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 VDD I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GBUFFD3BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GBUFFD4BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GBUFFD8BWP35 I Z VDD VSS
MM0 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net9 I VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 net9 I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt GDCAP10BWP35 VDD VSS
MM0 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM11 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM12 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM13 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM14 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM15 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM16 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM17 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM18 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM39 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM38 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM36 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM35 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM34 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM32 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM28 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM24 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDCAP12BWP35 VDD VSS
MM52 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM50 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM51 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM40 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM11 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM42 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM13 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM14 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM15 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM16 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM17 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM18 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS net159 net160 VSS nch_mac l=35.0n w=280.0n m=1
MM43 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM44 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM45 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 VSS net160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM30 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM32 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM28 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM24 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 net159 net160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 VDD net159 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDCAP2BWP35 VDD VSS
MM0 VSS net47 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 VSS net47 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net47 net43 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net47 net43 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 VDD net43 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 VDD net43 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDCAP3BWP35 VDD VSS
MM1 VSS net33 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 VSS net33 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 VSS net33 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 VSS net37 net33 VSS nch_mac l=35.0n w=280.0n m=1
MM5 VSS net37 net33 VSS nch_mac l=35.0n w=280.0n m=1
MM6 VSS net37 net33 VSS nch_mac l=35.0n w=280.0n m=1
MM11 VDD net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net37 net33 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net37 net33 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net37 net33 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 VDD net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 VDD net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDCAP4BWP35 VDD VSS
MM1 VSS net99 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 VSS net99 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 VSS net99 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 VSS net99 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 VSS net83 net99 VSS nch_mac l=35.0n w=280.0n m=1
MM6 VSS net83 net99 VSS nch_mac l=35.0n w=280.0n m=1
MM7 VSS net83 net99 VSS nch_mac l=35.0n w=280.0n m=1
MM8 VSS net83 net99 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net83 net99 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net83 net99 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net83 net99 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net83 net99 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 VDD net83 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 VDD net83 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 VDD net83 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 VDD net83 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDCAPBWP35 VDD VSS
MM1 VSS net47 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net47 net43 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 VDD net43 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDFCNQD1BWP35 D CP CDN Q VDD VSS
MM14 net0102 net0100 qf VSS nch_mac l=35.0n w=280.0n m=2
MM16 net0102 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf CP mq VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net176 mq net184 VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x CP net176 VSS nch_mac l=35.0n w=280.0n m=1
MM66 net184 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM55 net0100 CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net212 VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x CDN net208 VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net208 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net212 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net0102 CP qf VDD pch_mac l=35.0n w=340.0n m=2
MM17 net0102 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x CP net103 VDD pch_mac l=35.0n w=340.0n m=1
MM60 net0138 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net0138 mq VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 net0100 CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net103 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net0138 VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf net0100 mq VDD pch_mac l=35.0n w=340.0n m=2
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GDFQD1BWP35 D CP Q VDD VSS
MM1 net75 CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 mq_x net75 net83 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net83 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net67 CP mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM8 VSS mq net67 VSS nch_mac l=35.0n w=280.0n m=1
MM10 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 mq CP qf VSS nch_mac l=35.0n w=280.0n m=1
MM14 qf clkb net055 VSS nch_mac l=35.0n w=280.0n m=1
MM16 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net055 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net130 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 mq_x CP net130 VDD pch_mac l=35.0n w=340.0n m=1
MM5 VDD mq net119 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net119 net75 mq_x VDD pch_mac l=35.0n w=340.0n m=1
MM9 net75 CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 mq clkb qf VDD pch_mac l=35.0n w=340.0n m=1
MM15 qf CP net055 VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net055 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILL10BWP35 VDD VSS
MM39 net0139 net35 net0139 VSS nch_mac l=35.0n w=280.0n m=1
MM38 net0143 net35 net0143 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0150 net35 net0150 VSS nch_mac l=35.0n w=280.0n m=1
MM36 net0154 net35 net0154 VSS nch_mac l=35.0n w=280.0n m=1
MM29 net35 net30 net0154 VSS nch_mac l=35.0n w=280.0n m=1
MM30 net35 net30 net0143 VSS nch_mac l=35.0n w=280.0n m=1
MM31 net35 net30 net0150 VSS nch_mac l=35.0n w=280.0n m=1
MM35 net0167 net35 net0167 VSS nch_mac l=35.0n w=280.0n m=1
MM34 net0171 net35 net0171 VSS nch_mac l=35.0n w=280.0n m=1
MM33 net0178 net35 net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net35 net30 net0139 VSS nch_mac l=35.0n w=280.0n m=1
MM28 net35 net30 net0167 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net35 net30 net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM26 net35 net30 net0171 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net35 net30 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net35 net30 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net36 net35 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net35 net30 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net28 net35 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net21 net35 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM25 net65 net30 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM24 net81 net30 net81 VDD pch_mac l=35.0n w=340.0n m=1
MM23 net88 net30 net88 VDD pch_mac l=35.0n w=340.0n m=1
MM22 net92 net30 net92 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net93 net30 net93 VDD pch_mac l=35.0n w=340.0n m=1
MM20 net97 net30 net97 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net104 net30 net104 VDD pch_mac l=35.0n w=340.0n m=1
MM18 net30 net35 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net30 net35 net81 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net30 net35 net88 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net30 net35 net92 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net30 net35 net93 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net30 net35 net97 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net30 net35 net104 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net116 net30 net116 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net30 net35 net116 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net105 net30 net105 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net112 net30 net112 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net30 net35 net112 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net30 net35 net105 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILL12BWP35 VDD VSS
MM40 net35 net0154 net0130 VSS nch_mac l=35.0n w=280.0n m=1
MM41 net35 net0154 net0137 VSS nch_mac l=35.0n w=280.0n m=1
MM42 net0137 net35 net0137 VSS nch_mac l=35.0n w=280.0n m=1
MM43 net0130 net35 net0130 VSS nch_mac l=35.0n w=280.0n m=1
MM39 net0139 net35 net0139 VSS nch_mac l=35.0n w=280.0n m=1
MM38 net0143 net35 net0143 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0150 net35 net0150 VSS nch_mac l=35.0n w=280.0n m=1
MM36 net0185 net35 net0185 VSS nch_mac l=35.0n w=280.0n m=1
MM29 net35 net0154 net0185 VSS nch_mac l=35.0n w=280.0n m=1
MM30 net35 net0154 net0143 VSS nch_mac l=35.0n w=280.0n m=1
MM31 net35 net0154 net0150 VSS nch_mac l=35.0n w=280.0n m=1
MM35 net0167 net35 net0167 VSS nch_mac l=35.0n w=280.0n m=1
MM34 net0171 net35 net0171 VSS nch_mac l=35.0n w=280.0n m=1
MM33 net0178 net35 net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net35 net0154 net0139 VSS nch_mac l=35.0n w=280.0n m=1
MM28 net35 net0154 net0167 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net35 net0154 net0178 VSS nch_mac l=35.0n w=280.0n m=1
MM26 net35 net0154 net0171 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net35 net0154 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net35 net0154 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net36 net35 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net35 net0154 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net28 net35 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net21 net35 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM47 net0238 net0154 net0238 VDD pch_mac l=35.0n w=340.0n m=1
MM46 net0245 net0154 net0245 VDD pch_mac l=35.0n w=340.0n m=1
MM45 net0154 net35 net0238 VDD pch_mac l=35.0n w=340.0n m=1
MM44 net0154 net35 net0245 VDD pch_mac l=35.0n w=340.0n m=1
MM25 net65 net0154 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM24 net81 net0154 net81 VDD pch_mac l=35.0n w=340.0n m=1
MM23 net88 net0154 net88 VDD pch_mac l=35.0n w=340.0n m=1
MM22 net92 net0154 net92 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net93 net0154 net93 VDD pch_mac l=35.0n w=340.0n m=1
MM20 net97 net0154 net97 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net104 net0154 net104 VDD pch_mac l=35.0n w=340.0n m=1
MM18 net0154 net35 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net0154 net35 net81 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net0154 net35 net88 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net0154 net35 net92 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net0154 net35 net93 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net0154 net35 net97 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net0154 net35 net104 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net116 net0154 net116 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net0154 net35 net116 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net105 net0154 net105 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net112 net0154 net112 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net0154 net35 net112 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net0154 net35 net105 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILL2BWP35 VDD VSS
MM9 net18 net27 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net17 net18 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net24 net18 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net18 net27 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net27 net18 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net29 net27 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net44 net27 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net27 net18 net44 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILL3BWP35 VDD VSS
MM5 net29 net30 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net30 net35 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net30 net35 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net44 net30 net44 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net30 net35 net44 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net37 net30 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net35 net30 net064 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net20 net35 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 net35 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net35 net30 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net35 net30 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net064 net35 net064 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILL4BWP35 VDD VSS
MM15 net13 net14 net13 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net14 net19 net13 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net14 net19 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net14 net19 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net32 net14 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net14 net19 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net28 net14 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net21 net14 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net49 net19 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net19 net14 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net76 net19 net76 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net19 net14 net76 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net65 net19 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net72 net19 net72 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net19 net14 net72 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net19 net14 net65 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GFILLBWP35 VDD VSS
MM9 net22 net27 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net21 net22 net21 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net27 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net27 net22 net17 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GINVD1BWP35 I ZN VDD VSS
MM49 VSS I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VDD I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GINVD2BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GINVD3BWP35 I ZN VDD VSS
MM49 VSS I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=3
MM41 VDD I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GINVD4BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt GINVD8BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt GMUX2D1BWP35 I0 I1 S Z VDD VSS
MM11 Z net74 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net74 net70 net58 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net58 I0 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net54 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net74 S net54 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net70 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net74 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net74 S net82 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net82 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net78 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net74 net70 net78 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net70 S VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GMUX2D2BWP35 I0 I1 S Z VDD VSS
MM6 net57 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net85 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net62 I0 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net53 S net57 VSS nch_mac l=35.0n w=280.0n m=1
MM12 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 net57 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net53 net85 net62 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net93 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net85 S VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net53 S net97 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net97 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net93 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net53 net85 net93 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GMUX2ND1BWP35 I0 I1 S ZN VDD VSS
MM9 net82 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net58 S net55 VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net74 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net74 net58 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net58 net82 net66 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net66 I0 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net55 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net58 net82 net83 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net82 S VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN net74 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net74 net58 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net58 S net95 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net95 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net83 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GMUX2ND2BWP35 I0 I1 S ZN VDD VSS
MM15 ZN net103 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net103 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net103 net87 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net87 net83 net63 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net63 I0 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net87 S net59 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net59 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net83 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN net103 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN net103 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net103 net87 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net87 S net95 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net83 S VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net95 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net84 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net87 net83 net84 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GND2D1BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net10 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GND2D2BWP35 A1 A2 ZN VDD VSS
MM0 net33 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A1 net33 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net28 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GND2D3BWP35 A1 A2 ZN VDD VSS
MM9 net43 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 ZN A1 net43 VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt GND2D4BWP35 A1 A2 ZN VDD VSS
MM9 net72 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 ZN A1 net72 VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt GND3D1BWP35 A1 A2 A3 ZN VDD VSS
MM1 net30 A2 net26 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 VSS A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A3 net30 VSS nch_mac l=35.0n w=280.0n m=1
MM6 VDD A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GND3D2BWP35 A1 A2 A3 ZN VDD VSS
MM7 net33 A2 net61 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net33 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net41 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net46 A2 net41 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A1 net46 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net61 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM5 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GNR2D1BWP35 A1 A2 ZN VDD VSS
MM8 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A2 net9 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GNR2D2BWP35 A1 A2 ZN VDD VSS
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN A2 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net37 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A2 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net45 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GNR3D1BWP35 A1 A2 A3 ZN VDD VSS
MM1 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 VSS A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net59 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A1 net59 VDD pch_mac l=35.0n w=340.0n m=1
MM8 VDD A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GNR3D2BWP35 A1 A2 A3 ZN VDD VSS
MM0 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net56 A2 net44 VDD pch_mac l=35.0n w=340.0n m=2
MM4 ZN A1 net56 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net44 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt GOAI21D1BWP35 A1 A2 B ZN VDD VSS
MM49 VSS B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VDD B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GOAI21D2BWP35 A1 A2 B ZN VDD VSS
MM3 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A2 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A1 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN A1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net031 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net14 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GOR2D1BWP35 A1 A2 Z VDD VSS
MM49 VSS net6 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net6 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net6 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net6 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VDD net6 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net25 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net6 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GOR2D2BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GSDFCNQD1BWP35 SI D SE CP CDN Q VDD VSS
MM0 net0122 CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net0110 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net0110 net0122 qf VSS nch_mac l=35.0n w=280.0n m=2
MM47 net69 net0118 net89 VSS nch_mac l=35.0n w=280.0n m=1
MM51 net72 SI VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net32 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x CDN net32 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net69 VSS nch_mac l=35.0n w=280.0n m=1
MM66 net56 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x CP net53 VSS nch_mac l=35.0n w=280.0n m=1
MM57 net0118 SE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net53 mq net56 VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 net89 D VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf CP mq VSS nch_mac l=35.0n w=280.0n m=2
MM52 net69 SE net72 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0122 CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net0110 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net0110 CP qf VDD pch_mac l=35.0n w=340.0n m=2
XMSLTp1 qf net0122 mq VDD pch_mac l=35.0n w=340.0n m=2
MM43 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net96 VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net145 SE net89 VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net96 mq VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net148 SI VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net96 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0118 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x CP net145 VDD pch_mac l=35.0n w=340.0n m=1
MM42 net145 net0118 net148 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GTIEHBWP35 Z VDD VSS
MM49 VSS net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net10 net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VDD net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 Z net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GTIELBWP35 ZN VDD VSS
MM49 VSS net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 VDD net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net10 net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GXNR2D1BWP35 A1 A2 ZN VDD VSS
MM1 net064 net6 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net6 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net45 net44 net064 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net6 A1 net45 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net44 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net45 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net45 A1 net033 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net033 net6 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net6 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net6 net44 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net44 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN net45 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GXNR2D2BWP35 A1 A2 ZN VDD VSS
MM3 net37 net62 net49 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net49 net40 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net37 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net40 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM17 net40 A1 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net62 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net37 A1 net80 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net80 net40 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN net37 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net40 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net40 net62 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net62 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GXOR2D1BWP35 A1 A2 Z VDD VSS
MM1 net057 net49 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net46 A1 net057 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net24 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net49 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net46 net24 net49 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net46 net24 net036 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net036 net49 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net24 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net49 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net46 A1 net49 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt GXOR2D2BWP35 A1 A2 Z VDD VSS
MM1 net56 net57 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net60 A1 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net34 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net57 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 Z net60 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM17 net60 net34 net57 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net60 net34 net77 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net77 net57 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 Z net60 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 net34 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net57 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net60 A1 net57 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt HA1D0BWP35 A B S CO VDD VSS
MM11 net67 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net139 A VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 net99 B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net99 A VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 CO net99 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net139 A VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net135 net139 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net135 net67 net124 VDD pch_mac l=35.0n w=260.0n m=1
MM7 net139 B net124 VDD pch_mac l=35.0n w=260.0n m=1
MM9 S net124 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net139 A VSS VSS nch_mac l=35.0n w=260.0n m=2
MM2 net135 net139 VSS VSS nch_mac l=35.0n w=260.0n m=1
MM5 net135 B net124 VSS nch_mac l=35.0n w=260.0n m=1
MM6 net139 net67 net124 VSS nch_mac l=35.0n w=260.0n m=1
MM8 S net124 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net67 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 CO net99 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net99 A net107 VSS nch_mac l=35.0n w=140.0n m=1
MM15 net107 B VSS VSS nch_mac l=35.0n w=140.0n m=1
.ends
.subckt HA1D1BWP35 A B S CO VDD VSS
MM1 net046 A VSS VSS nch_mac l=35.0n w=260.0n m=2
MM2 net074 net046 VSS VSS nch_mac l=35.0n w=260.0n m=1
MM5 net074 B net085 VSS nch_mac l=35.0n w=260.0n m=1
MM6 net046 net090 net085 VSS nch_mac l=35.0n w=260.0n m=1
MM8 S net085 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net090 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 CO net034 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net034 A net0116 VSS nch_mac l=35.0n w=270.0n m=1
MM15 net0116 B VSS VSS nch_mac l=35.0n w=270.0n m=1
MM18 net046 A VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net034 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net034 A VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 CO net034 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net046 A VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net074 net046 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net074 net090 net085 VDD pch_mac l=35.0n w=260.0n m=1
MM7 net046 B net085 VDD pch_mac l=35.0n w=260.0n m=1
MM9 S net085 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net090 B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt HA1D2BWP35 A B S CO VDD VSS
MM18 net92 A VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net104 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net104 A VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 CO net104 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net92 A VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net88 net92 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net88 net124 net129 VDD pch_mac l=35.0n w=260.0n m=1
MM7 net92 B net129 VDD pch_mac l=35.0n w=260.0n m=1
MM9 S net129 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net124 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net92 A VSS VSS nch_mac l=35.0n w=260.0n m=2
MM2 net88 net92 VSS VSS nch_mac l=35.0n w=260.0n m=1
MM5 net88 B net129 VSS nch_mac l=35.0n w=260.0n m=1
MM6 net92 net124 net129 VSS nch_mac l=35.0n w=260.0n m=1
MM8 S net129 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net124 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 CO net104 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 net104 A net113 VSS nch_mac l=35.0n w=270.0n m=1
MM15 net113 B VSS VSS nch_mac l=35.0n w=270.0n m=1
.ends
.subckt HA1D4BWP35 A B S CO VDD VSS
MM19 net68 A net086 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net104 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net68 A net104 VSS nch_mac l=35.0n w=280.0n m=1
MM12 CO net68 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net92 A VSS VSS nch_mac l=35.0n w=280.0n m=3
MM2 net88 net92 VSS VSS nch_mac l=35.0n w=165.00n m=2
MM5 net88 B net83 VSS nch_mac l=35.0n w=165.00n m=1
MM6 net92 net36 net83 VSS nch_mac l=35.0n w=275.00n m=1
MM8 S net83 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net36 B VSS VSS nch_mac l=35.0n w=275.00n m=1
MM18 net086 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net36 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 S net83 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net92 B net83 VDD pch_mac l=35.0n w=270.0n m=1
MM4 net88 net36 net83 VDD pch_mac l=35.0n w=270.0n m=1
MM3 net88 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 net68 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net68 A VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 CO net68 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net92 A VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt IAO21D0BWP35 A1 A2 B ZN VDD VSS
MM6 ZN net035 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net035 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net035 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN B net39 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net39 net035 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net50 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net035 A1 net50 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IAO21D1BWP35 A1 A2 B ZN VDD VSS
MM6 ZN net051 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net051 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net051 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN B net27 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net27 net051 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net23 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net051 A1 net23 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IAO21D2BWP35 A1 A2 B ZN VDD VSS
MM6 ZN net27 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net27 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net27 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net045 net27 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net27 A1 net43 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net43 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net39 net27 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B net045 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IAO21D4BWP35 A1 A2 B ZN VDD VSS
MM6 ZN net055 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 net055 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net055 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net055 A1 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net27 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net23 net055 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM8 ZN B net23 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt IAO22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM13 net56 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN net72 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN B1 net56 VSS nch_mac l=35.0n w=140.0n m=1
MM15 net72 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net72 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net44 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 ZN net72 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net44 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net55 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 net72 A1 net55 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IAO22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM13 net52 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net36 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN B1 net52 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net36 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net36 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net64 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN net36 net64 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net64 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net59 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 net36 A1 net59 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IAO22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 net39 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net057 B2 net39 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net40 net057 net48 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net48 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net48 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN net40 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net057 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net057 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net75 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net40 net057 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net40 A2 net75 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN net40 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt IAO22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 net56 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net033 B2 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net64 net033 net72 VSS nch_mac l=35.0n w=280.0n m=2
MM4 net72 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net72 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 ZN net64 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net033 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net033 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net40 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net64 net033 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net64 A2 net40 VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN net64 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt IIND4D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net72 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net68 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net093 B1 net36 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net36 B2 net39 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN net72 net093 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net39 net68 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net72 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net68 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 ZN net72 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 ZN net68 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IIND4D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM7 net67 net56 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net52 net0116 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net63 B2 net67 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net0116 B1 net63 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net56 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net52 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN net56 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN net52 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net56 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net52 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IIND4D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net78 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net98 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net69 B1 net61 VSS nch_mac l=35.0n w=280.0n m=2
MM5 net61 B2 net70 VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN net78 net69 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net70 net98 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net78 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN net78 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN net98 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net98 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IIND4D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net45 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net61 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net76 B1 net68 VSS nch_mac l=35.0n w=280.0n m=4
MM5 net68 B2 net77 VSS nch_mac l=35.0n w=280.0n m=4
MM6 ZN net45 net76 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net77 net61 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 net61 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM11 ZN net61 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net45 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 ZN net45 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt IINR4D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net51 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net47 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN net51 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net51 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN net47 net70 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net70 net51 net66 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net66 B1 net62 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net62 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IINR4D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN net54 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN net58 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net58 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net54 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN net58 net41 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net41 net54 net46 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net46 B1 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net49 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net74 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net69 B1 net74 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net65 net54 net69 VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN net58 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net58 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net54 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IINR4D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 ZN net91 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN net95 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net95 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net91 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net110 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net106 B1 net110 VDD pch_mac l=35.0n w=340.0n m=4
MM9 net102 net91 net106 VDD pch_mac l=35.0n w=340.0n m=4
MM8 ZN net95 net102 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net95 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net91 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IINR4D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net34 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net62 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN net62 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 ZN net34 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net34 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net62 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 ZN net62 net45 VDD pch_mac l=35.0n w=340.0n m=8
MM9 net45 net34 net50 VDD pch_mac l=35.0n w=340.0n m=8
MM10 net50 B1 net54 VDD pch_mac l=35.0n w=340.0n m=8
MM11 net54 B2 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt IND2D0BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net025 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net036 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net025 net036 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN net036 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net036 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IND2D16BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=16
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt IND2D1BWP35 A1 B1 ZN VDD VSS
MM1 net27 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net34 net27 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN B1 net34 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net27 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN net27 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IND2D2BWP35 A1 B1 ZN VDD VSS
MM7 net024 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net052 net024 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN net052 net036 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net036 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN net052 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IND2D4BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=4
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt IND2D6BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=6
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt IND2D8BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=8
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt IND2XD0BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net025 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net036 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net025 net036 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN net036 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net036 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IND2XD16BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net025 VSS nch_mac l=35.0n w=280.0n m=32
MM1 net036 A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net025 net036 VSS VSS nch_mac l=35.0n w=280.0n m=32
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN net036 VDD VDD pch_mac l=35.0n w=170.0n m=32
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=31
MM0 net036 A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt IND2XD1BWP35 A1 B1 ZN VDD VSS
MM1 net27 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net34 net27 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN B1 net34 VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net27 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN net27 VDD VDD pch_mac l=35.0n w=170.0n m=2
.ends
.subckt IND2XD2BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net036 VSS nch_mac l=35.0n w=280.0n m=4
MM5 net036 net052 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN net052 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=3
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN net052 VDD VDD pch_mac l=35.0n w=170.0n m=3
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt IND2XD4BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=8
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=170.0n m=8
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=7
.ends
.subckt IND2XD6BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=12
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=170.0n m=12
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=11
.ends
.subckt IND2XD8BWP35 A1 B1 ZN VDD VSS
MM4 ZN B1 net43 VSS nch_mac l=35.0n w=280.0n m=16
MM1 net20 A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net43 net20 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 ZN net20 VDD VDD pch_mac l=35.0n w=170.0n m=16
MM3 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=15
.ends
.subckt IND3D0BWP35 A1 B1 B2 ZN VDD VSS
MM4 ZN B2 net048 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net51 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net048 B1 net46 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net46 net51 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN net51 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net51 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IND3D16BWP35 A1 B1 B2 ZN VDD VSS
MM1 net36 A1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM4 ZN B2 net44 VSS nch_mac l=35.0n w=280.0n m=16
MM5 net44 B1 net40 VSS nch_mac l=35.0n w=280.0n m=16
MM7 net40 net36 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM6 ZN net36 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM0 net36 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt IND3D1BWP35 A1 B1 B2 ZN VDD VSS
MM7 net34 net23 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net31 B1 net34 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN B2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net23 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN net23 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net23 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IND3D2BWP35 A1 B1 B2 ZN VDD VSS
MM1 net37 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN B2 net57 VSS nch_mac l=35.0n w=280.0n m=2
MM5 net57 B1 net53 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net53 net37 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net37 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN net37 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt IND3D4BWP35 A1 B1 B2 ZN VDD VSS
MM1 net36 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN B2 net44 VSS nch_mac l=35.0n w=280.0n m=4
MM5 net44 B1 net40 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net40 net36 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 ZN net36 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net36 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt IND3D6BWP35 A1 B1 B2 ZN VDD VSS
MM1 net36 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN B2 net44 VSS nch_mac l=35.0n w=280.0n m=6
MM5 net44 B1 net40 VSS nch_mac l=35.0n w=280.0n m=6
MM7 net40 net36 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM6 ZN net36 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM0 net36 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt IND3D8BWP35 A1 B1 B2 ZN VDD VSS
MM1 net36 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 ZN B2 net44 VSS nch_mac l=35.0n w=280.0n m=8
MM5 net44 B1 net40 VSS nch_mac l=35.0n w=280.0n m=8
MM7 net40 net36 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 ZN net36 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM0 net36 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt IND4D0BWP35 A1 B1 B2 B3 ZN VDD VSS
MM9 net37 net46 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN B3 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net46 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net45 B2 net34 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net34 B1 net37 VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN net46 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net46 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IND4D1BWP35 A1 B1 B2 B3 ZN VDD VSS
MM1 net42 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net57 net42 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net53 B1 net57 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net50 B2 net53 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN B3 net50 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net42 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 ZN net42 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IND4D2BWP35 A1 B1 B2 B3 ZN VDD VSS
MM4 ZN net46 net33 VSS nch_mac l=35.0n w=280.0n m=2
MM5 net33 B1 net38 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net38 B2 net42 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net42 B3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net46 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN net46 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 ZN B3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net46 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IND4D4BWP35 A1 B1 B2 B3 ZN VDD VSS
MM1 net63 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN net63 net55 VSS nch_mac l=35.0n w=280.0n m=4
MM5 net55 B1 net51 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net51 B2 net47 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net47 B3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN B3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net63 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN net63 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INR2D0BWP35 A1 B1 ZN VDD VSS
MM1 net019 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN net019 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net019 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN B1 net29 VDD pch_mac l=35.0n w=170.0n m=1
MM5 net29 net019 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt INR2D16BWP35 A1 B1 ZN VDD VSS
MM3 ZN net052 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM5 net25 net052 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN B1 net25 VDD pch_mac l=35.0n w=340.0n m=16
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt INR2D1BWP35 A1 B1 ZN VDD VSS
MM3 ZN net027 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net027 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net24 net027 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net027 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt INR2D2BWP35 A1 B1 ZN VDD VSS
MM1 net37 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN net37 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net034 net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net37 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN B1 net034 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net29 net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR2D4BWP35 A1 B1 ZN VDD VSS
MM3 ZN net052 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net039 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN B1 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN B1 net028 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net028 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net023 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN B1 net023 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net25 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt INR2D6BWP35 A1 B1 ZN VDD VSS
MM3 ZN net052 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM26 ZN B1 net0128 VDD pch_mac l=35.0n w=340.0n m=1
MM25 net0128 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 ZN B1 net0139 VDD pch_mac l=35.0n w=340.0n m=1
MM22 ZN B1 net0140 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net0140 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net0148 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 ZN B1 net0148 VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN B1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN B1 net0160 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net0160 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM24 net0139 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net25 net052 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt INR2D8BWP35 A1 B1 ZN VDD VSS
MM3 ZN net052 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM1 net052 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net25 net052 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 ZN B1 net25 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net052 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt INR2XD0BWP35 A1 B1 ZN VDD VSS
MM3 ZN net37 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net37 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN B1 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net37 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net20 net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR2XD16BWP35 A1 B1 ZN VDD VSS
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM2 ZN net17 VSS VSS nch_mac l=35.0n w=140.0n m=32
MM1 net17 A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM5 net37 net17 VDD VDD pch_mac l=35.0n w=340.0n m=32
MM4 ZN B1 net37 VDD pch_mac l=35.0n w=340.0n m=32
MM0 net17 A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt INR2XD1BWP35 A1 B1 ZN VDD VSS
MM3 ZN net028 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net028 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net035 net028 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN B1 net035 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net37 net028 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net028 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR2XD2BWP35 A1 B1 ZN VDD VSS
MM1 net29 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM3 ZN net29 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM6 net040 net29 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN B1 net040 VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN B1 net028 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net028 net29 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net024 net29 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN B1 net024 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net29 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net24 net29 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR2XD4BWP35 A1 B1 ZN VDD VSS
MM3 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN net17 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net17 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net37 B1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 ZN net17 net37 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net17 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt INR2XD6BWP35 A1 B1 ZN VDD VSS
MM3 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM2 ZN net047 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 net047 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net37 B1 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM4 ZN net047 net37 VDD pch_mac l=35.0n w=340.0n m=12
MM0 net047 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt INR2XD8BWP35 A1 B1 ZN VDD VSS
MM6 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=15
MM2 ZN net17 VSS VSS nch_mac l=35.0n w=140.0n m=16
MM1 net17 A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 net37 net17 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN B1 net37 VDD pch_mac l=35.0n w=340.0n m=16
MM0 net17 A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt INR3D0BWP35 A1 B1 B2 ZN VDD VSS
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net079 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN net079 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net23 net079 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net079 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN B2 net31 VDD pch_mac l=35.0n w=170.0n m=1
MM5 net31 B1 net23 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt INR3D16BWP35 A1 B1 B2 ZN VDD VSS
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt INR3D1BWP35 A1 B1 B2 ZN VDD VSS
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net30 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net30 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 ZN B2 net50 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net50 B1 net53 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net53 net30 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net30 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net62 net30 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B2 net69 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net69 B1 net62 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR3D2BWP35 A1 B1 B2 ZN VDD VSS
MM1 net74 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN net74 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 ZN B2 net54 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net54 B1 net50 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net50 net74 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net74 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net37 net74 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B2 net34 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net34 B1 net37 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR3D4BWP35 A1 B1 B2 ZN VDD VSS
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=4
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INR3D6BWP35 A1 B1 B2 ZN VDD VSS
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=6
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt INR3D8BWP35 A1 B1 B2 ZN VDD VSS
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=8
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt INR3XD0BWP35 A1 B1 B2 ZN VDD VSS
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR3XD16BWP35 A1 B1 B2 ZN VDD VSS
MM9 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=32
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=32
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=32
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=32
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=32
.ends
.subckt INR3XD1BWP35 A1 B1 B2 ZN VDD VSS
MM11 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net057 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B2 net065 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net065 B1 net057 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR3XD2BWP35 A1 B1 B2 ZN VDD VSS
MM8 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=4
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INR3XD4BWP35 A1 B1 B2 ZN VDD VSS
MM8 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=7
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=8
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=8
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=8
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt INR3XD6BWP35 A1 B1 B2 ZN VDD VSS
MM8 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=12
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=12
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=11
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=12
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt INR3XD8BWP35 A1 B1 B2 ZN VDD VSS
MM8 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net47 VSS VSS nch_mac l=35.0n w=140.0n m=16
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=16
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=15
MM1 net47 A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM6 net43 net47 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN B2 net42 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net42 B1 net43 VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt INR4D0BWP35 A1 B1 B2 B3 ZN VDD VSS
MM9 ZN B3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net27 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN net27 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net62 net27 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net59 B1 net62 VDD pch_mac l=35.0n w=170.0n m=1
MM0 net27 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN B3 net51 VDD pch_mac l=35.0n w=170.0n m=1
MM5 net51 B2 net59 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt INR4D1BWP35 A1 B1 B2 B3 ZN VDD VSS
MM9 ZN B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net51 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN net51 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN B3 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net39 B2 net43 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net43 B1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net47 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net51 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 net70 net51 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net66 B2 net67 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B3 net66 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net67 B1 net70 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INR4D2BWP35 A1 B1 B2 B3 ZN VDD VSS
MM9 ZN B3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net50 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net50 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net50 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net69 net50 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 net65 B2 net66 VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B3 net65 VDD pch_mac l=35.0n w=340.0n m=4
MM6 net66 B1 net69 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INR4D4BWP35 A1 B1 B2 B3 ZN VDD VSS
MM9 ZN B3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net46 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN net46 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 ZN B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net46 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 net42 net46 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 net37 B2 net30 VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B3 net37 VDD pch_mac l=35.0n w=340.0n m=4
MM6 net30 B1 net42 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INVD0BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt INVD12BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=12
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt INVD15BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=15
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=15
.ends
.subckt INVD16BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=16
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt INVD18BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=18
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=18
.ends
.subckt INVD1BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt INVD20BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=20
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=20
.ends
.subckt INVD21BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=21
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=21
.ends
.subckt INVD24BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=24
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=24
.ends
.subckt INVD2BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt INVD32BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=32
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=32
.ends
.subckt INVD3BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt INVD4BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt INVD6BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=6
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt INVD8BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt INVD9BWP35 I ZN VDD VSS
MM1 ZN I VSS VSS nch_mac l=35.0n w=280.0n m=9
MM0 ZN I VDD VDD pch_mac l=35.0n w=340.0n m=9
.ends
.subckt IOA21D0BWP35 A1 A2 B ZN VDD VSS
MM7 ZN B net40 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net40 net29 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net29 A1 net52 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net52 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN net29 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net29 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net29 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IOA21D1BWP35 A1 A2 B ZN VDD VSS
MM7 ZN B net29 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net29 net41 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net25 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net41 A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN net41 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net41 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net41 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IOA21D2BWP35 A1 A2 B ZN VDD VSS
MM8 net040 net28 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN B net040 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net28 A1 net51 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net51 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net39 net28 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B net39 VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 ZN net28 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net28 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net28 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IOA21D4BWP35 A1 A2 B ZN VDD VSS
MM7 ZN net47 net35 VSS nch_mac l=35.0n w=280.0n m=4
MM6 net35 B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net30 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net47 A1 net30 VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN net47 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net47 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IOA22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net30 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN net66 net30 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net30 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net66 A2 net46 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net46 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net57 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 ZN B2 net57 VDD pch_mac l=35.0n w=170.0n m=1
MM8 ZN net66 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net66 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net66 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IOA22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net66 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN net30 net66 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net66 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net30 A2 net50 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net50 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net46 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B2 net46 VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN net30 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net30 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net30 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt IOA22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 ZN net48 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net36 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net36 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net51 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net48 A1 net51 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net48 net36 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 ZN net48 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net60 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net36 B1 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net48 net36 net76 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net76 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net76 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt IOA22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM1 net36 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net36 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net44 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net48 A1 net44 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net48 net36 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 ZN net48 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 ZN net48 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net60 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net36 B1 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net48 net36 net76 VDD pch_mac l=35.0n w=340.0n m=2
MM5 net76 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net76 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LHCND1BWP35 D E CDN Q QN VDD VSS
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net100 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net100 D net103 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net103 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net112 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net112 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net91 VSS nch_mac l=35.0n w=100n m=1
MM19 net124 qf net91 VSS nch_mac l=35.0n w=100n m=1
MM20 net124 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net52 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net52 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net112 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net112 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net83 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net83 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCND2BWP35 D E CDN Q QN VDD VSS
MM23 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM22 Q net143 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net107 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net107 D net110 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net110 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net143 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net82 VSS nch_mac l=35.0n w=100n m=1
MM19 net75 qf net82 VSS nch_mac l=35.0n w=100n m=1
MM20 net75 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM24 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM21 Q net143 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net158 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net158 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net143 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net134 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net134 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCND4BWP35 D E CDN Q QN VDD VSS
MM35 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM31 Q net139 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM20 net195 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net195 qf net202 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net202 VSS nch_mac l=35.0n w=100n m=1
MM11 net139 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net226 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net223 D net226 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net223 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM36 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM32 Q net139 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net130 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net130 VDD pch_mac l=35.0n w=100n m=1
MM10 net139 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net155 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net155 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCNDD1BWP35 D E CDN Q QN VDD VSS
MM21 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net57 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net57 qf net60 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net60 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net125 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net125 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net81 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net85 D net81 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net85 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net101 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 qf_x clkbb net112 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net112 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net125 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net125 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net101 VDD pch_mac l=35.0n w=250.0n m=1
.ends
.subckt LHCNDD2BWP35 D E CDN Q QN VDD VSS
MM25 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM22 Q net82 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net150 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net150 D net146 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net146 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net82 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net125 VSS nch_mac l=35.0n w=100n m=1
MM19 net118 qf net125 VSS nch_mac l=35.0n w=100n m=1
MM20 net118 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM26 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM21 Q net82 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net97 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net97 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net82 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net69 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net69 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCNDD4BWP35 D E CDN Q QN VDD VSS
MM37 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM35 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM31 Q net125 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM20 net141 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net141 qf net140 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net140 VSS nch_mac l=35.0n w=100n m=1
MM11 net125 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net116 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net113 D net116 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net113 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM36 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM32 Q net125 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net216 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net216 VDD pch_mac l=35.0n w=100n m=1
MM10 net125 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net185 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net185 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCNDQD1BWP35 D E CDN Q VDD VSS
MM21 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net97 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net97 qf net104 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net104 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net73 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net73 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net117 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net121 D net117 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net121 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net53 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 qf_x clkbb net68 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net68 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net73 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net73 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net53 VDD pch_mac l=35.0n w=250.0n m=1
.ends
.subckt LHCNDQD2BWP35 D E CDN Q VDD VSS
MM25 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net92 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net92 qf net91 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net91 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net80 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 net80 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net71 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net68 D net71 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net68 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 qf_x clkbb net139 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net139 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net80 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net80 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net112 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net112 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LHCNDQD4BWP35 D E CDN Q VDD VSS
MM37 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net167 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net167 qf net166 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net166 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net91 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net91 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net146 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net143 D net146 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net143 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net106 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net106 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net91 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net91 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net75 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net75 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCNQD1BWP35 D E CDN Q VDD VSS
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net71 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net71 D net67 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net67 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net59 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net59 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net50 VSS nch_mac l=35.0n w=100n m=1
MM19 net43 qf net50 VSS nch_mac l=35.0n w=100n m=1
MM20 net43 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net110 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net110 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net59 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net59 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net86 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net86 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCNQD2BWP35 D E CDN Q VDD VSS
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net0122 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0122 D net0125 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0125 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net066 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net066 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net0101 VSS nch_mac l=35.0n w=100n m=1
MM19 net094 qf net0101 VSS nch_mac l=35.0n w=100n m=1
MM20 net094 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net082 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net082 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net066 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net066 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net057 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net057 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCNQD4BWP35 D E CDN Q VDD VSS
MM20 net104 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net104 qf net103 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net103 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net92 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net92 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net83 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net80 D net83 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net80 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net159 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net159 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net92 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net92 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net132 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net132 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCSND1BWP35 D E CDN SDN Q QN VDD VSS
MM22 net54 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net66 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net66 D net70 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net70 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net54 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net126 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net126 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net93 VSS nch_mac l=35.0n w=100n m=1
MM19 net98 qf net93 VSS nch_mac l=35.0n w=100n m=1
MM20 net98 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net117 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net117 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net126 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net126 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net145 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net145 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSND2BWP35 D E CDN SDN Q QN VDD VSS
MM26 net152 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net157 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net157 D net153 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net153 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net152 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net145 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net145 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net132 VSS nch_mac l=35.0n w=100n m=1
MM19 net129 qf net132 VSS nch_mac l=35.0n w=100n m=1
MM20 net129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net104 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net104 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net145 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net145 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net76 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net76 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSND4BWP35 D E CDN SDN Q QN VDD VSS
MM25 net102 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net138 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net138 qf net141 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net141 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net242 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net242 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf SDN net102 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net169 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net166 D net169 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net166 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net181 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net181 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net233 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net233 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net242 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net242 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net258 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net258 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCSNDD1BWP35 D E CDN SDN Q QN VDD VSS
MM24 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net0109 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net0121 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0121 D net0124 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0124 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0109 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0133 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0133 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net0152 VSS nch_mac l=35.0n w=100n m=1
MM19 net0153 qf net0152 VSS nch_mac l=35.0n w=100n m=1
MM20 net0153 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM23 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net076 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net076 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0133 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0133 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net0104 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net0104 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNDD2BWP35 D E CDN SDN Q QN VDD VSS
MM27 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net0126 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net0106 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0106 D net0102 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0102 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0126 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0150 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0150 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net081 VSS nch_mac l=35.0n w=100n m=1
MM19 net074 qf net081 VSS nch_mac l=35.0n w=100n m=1
MM20 net074 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM28 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0165 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net0165 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0150 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0150 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net0137 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net0137 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNDD4BWP35 D E CDN SDN Q QN VDD VSS
MM42 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net272 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net236 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net236 qf net235 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net235 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net128 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net128 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf SDN net272 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net211 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net208 D net211 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net208 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net192 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net192 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net143 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net143 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net128 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net128 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net112 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net112 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCSNDQD1BWP35 D E CDN SDN Q VDD VSS
MM24 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net74 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net79 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net79 D net75 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net75 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net74 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net67 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net67 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net58 VSS nch_mac l=35.0n w=100n m=1
MM19 net51 qf net58 VSS nch_mac l=35.0n w=100n m=1
MM20 net51 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM23 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net126 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net126 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net67 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net67 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net102 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net102 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNDQD2BWP35 D E CDN SDN Q VDD VSS
MM27 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net0133 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net0138 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0138 D net0134 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0134 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0126 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0126 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net0117 VSS nch_mac l=35.0n w=100n m=1
MM19 net0114 qf net0117 VSS nch_mac l=35.0n w=100n m=1
MM20 net0114 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM28 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net089 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net089 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0126 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0126 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net065 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net065 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNDQD4BWP35 D E CDN SDN Q VDD VSS
MM37 net070 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net070 VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkbb net086 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net086 D net090 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net090 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 net098 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM42 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net0130 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net0130 qf net0137 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net0137 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net098 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM41 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net0181 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net0181 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net098 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net098 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net0202 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net0202 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHCSNQD1BWP35 D E CDN SDN Q VDD VSS
MM22 net0110 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net0115 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0115 D net0118 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0118 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0110 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net059 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net059 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net094 VSS nch_mac l=35.0n w=100n m=1
MM19 net087 qf net094 VSS nch_mac l=35.0n w=100n m=1
MM20 net087 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net075 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net075 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net059 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net059 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net050 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net050 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNQD2BWP35 D E CDN SDN Q VDD VSS
MM26 net084 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x E net089 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net089 D net085 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net085 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net084 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net077 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net077 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net068 VSS nch_mac l=35.0n w=100n m=1
MM19 net061 qf net068 VSS nch_mac l=35.0n w=100n m=1
MM20 net061 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0144 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net0144 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net077 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net077 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net0116 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net0116 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHCSNQD4BWP35 D E CDN SDN Q VDD VSS
MM20 net0176 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net0176 qf net0171 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net0171 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net088 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net088 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net0151 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0148 D net0151 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net0148 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net0132 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0132 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net079 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkb net079 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM10 net088 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 Q net088 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net099 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net099 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHD1BWP35 D E Q QN VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net051 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net063 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net063 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS qf net051 VSS nch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net087 clkbb qf_x VDD pch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0102 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net0102 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net087 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHD2BWP35 D E Q QN VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 qf_x clkb net082 VSS nch_mac l=35.0n w=100n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net112 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net112 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net082 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM17 net050 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM2 net80 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net80 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 qf_x clkbb net050 VDD pch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LHD4BWP35 D E Q QN VDD VSS
MM19 qf_x clkb net040 VSS nch_mac l=35.0n w=100n m=1
MM16 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM15 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x clkbb net078 VSS nch_mac l=35.0n w=155.00n m=1
MM3 net078 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 net040 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM18 net080 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM17 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net0113 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 qf_x clkb net0113 VDD pch_mac l=35.0n w=260.0n m=1
MM4 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 qf_x clkbb net080 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHQD1BWP35 D E Q VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net076 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net088 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net088 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS qf net076 VSS nch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net071 clkbb qf_x VDD pch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net052 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net052 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net071 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHQD2BWP35 D E Q VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net082 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net0201 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0201 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM19 VSS qf net082 VSS nch_mac l=35.0n w=100n m=1
MM2 net094 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net094 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net0111 VDD pch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net0111 clkbb qf_x VDD pch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LHQD4BWP35 D E Q VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net074 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkbb net083 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net083 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM19 VSS qf net074 VSS nch_mac l=35.0n w=100n m=1
MM2 net066 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net066 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM16 VDD qf net043 VDD pch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net043 clkbb qf_x VDD pch_mac l=35.0n w=100n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHQOPTDAD1BWP35 D E Q VDD VSS
MM13 Q net92 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM8 net090 net0240 VSS VSS nch_mac l=35n w=100n m=1 nf=1
XMN11 EB E VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 net0240 net92 VSS VSS nch_mac l=35n w=100n m=1 nf=1
MM7 EP EB VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM11 net92 D net0123 VSS nch_mac l=35n w=210.0n m=1 nf=1
MM12 net0123 EP VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
MM9 net92 EB net090 VSS nch_mac l=35n w=100n m=1 nf=1
MM4 net92 EP net200 VDD pch_mac l=35n w=100n m=1 nf=1
XMP12 net0199 EB VDD VDD pch_mac l=35n w=270.0n m=2 nf=1
MM5 EB E VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM6 EP EB VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM2 Q net92 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net0240 net92 VDD VDD pch_mac l=35n w=100n m=1 nf=1
MM3 net200 net0240 VDD VDD pch_mac l=35n w=100n m=1 nf=1
MM0 net92 D net0199 VDD pch_mac l=35n w=270.0n m=1 nf=1
.ends
.subckt LHQOPTDAD2BWP35 D E Q VDD VSS
MM13 Q net92 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM8 net090 net0240 VSS VSS nch_mac l=35n w=100n m=1 nf=1
XMN11 EB E VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 net0240 net92 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 EP EB VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM11 net92 D net0123 VSS nch_mac l=35n w=210.0n m=1 nf=1
MM12 net0123 EP VSS VSS nch_mac l=35n w=210.0n m=2 nf=1
MM9 net92 EB net090 VSS nch_mac l=35n w=100n m=1 nf=1
MM4 net92 EP net200 VDD pch_mac l=35n w=100n m=1 nf=1
XMP12 net0199 EB VDD VDD pch_mac l=35n w=270.0n m=2 nf=1
MM5 EB E VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM6 EP EB VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM2 Q net92 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net0240 net92 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 net200 net0240 VDD VDD pch_mac l=35n w=100n m=1 nf=1
MM0 net92 D net0199 VDD pch_mac l=35n w=270.0n m=1 nf=1
.ends
.subckt LHQOPTDAD4BWP35 D E Q VDD VSS
MM15 net92 D net0123 VSS nch_mac l=35n w=210.0n m=1 nf=1
MM13 Q net92 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM8 net090 net0240 VSS VSS nch_mac l=35n w=120.0n m=1 nf=1
XMN11 EB E VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 net0240 net92 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 EP EB VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM11 net92 D net0123 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM12 net0123 EP VSS VSS nch_mac l=35n w=210.0n m=4 nf=1
MM9 net92 EB net090 VSS nch_mac l=35n w=120.0n m=1 nf=1
MM4 net92 EP net200 VDD pch_mac l=35n w=100n m=1 nf=1
MM14 net92 D net0199 VDD pch_mac l=35n w=270.0n m=1 nf=1
XMP12 net0199 EB VDD VDD pch_mac l=35n w=270.0n m=4 nf=1
MM5 EB E VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM6 EP EB VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM2 Q net92 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net0240 net92 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 net200 net0240 VDD VDD pch_mac l=35n w=100n m=1 nf=1
MM0 net92 D net0199 VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt LHQOPTDAD8BWP35 D E Q VDD VSS
MM13 Q net92 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM8 net090 net0240 VSS VSS nch_mac l=35n w=100n m=1 nf=1
XMN11 EB E VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 net0240 net92 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 EP EB VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM11 net92 D net0123 VSS nch_mac l=35n w=210.0n m=3 nf=1
MM12 net0123 EP VSS VSS nch_mac l=35n w=210.0n m=6 nf=1
MM9 net92 EB net090 VSS nch_mac l=35n w=100n m=1 nf=1
MM4 net92 EP net200 VDD pch_mac l=35n w=100n m=1 nf=1
XMP12 net0199 EB VDD VDD pch_mac l=35n w=270.0n m=6 nf=1
MM5 EB E VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM6 EP EB VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM2 Q net92 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net0240 net92 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 net200 net0240 VDD VDD pch_mac l=35n w=100n m=1 nf=1
MM0 net92 D net0199 VDD pch_mac l=35n w=270.0n m=3 nf=1
.ends
.subckt LHSND1BWP35 D E SDN Q QN VDD VSS
MM22 net0122 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net0110 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0110 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0122 VSS nch_mac l=35.0n w=240.0n m=1
MM11 net0102 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0102 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net089 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net089 VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=215.00n m=1
MM2 net073 D VDD VDD pch_mac l=35.0n w=215.00n m=1
MM3 qf_x clkb net073 VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0102 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0102 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net049 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net049 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSND2BWP35 D E SDN Q QN VDD VSS
MM26 net081 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net069 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net069 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net081 VSS nch_mac l=35.0n w=240.0n m=1
MM11 net0101 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0101 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net048 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net048 VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=215.00n m=1
MM2 net0113 D VDD VDD pch_mac l=35.0n w=215.00n m=1
MM3 qf_x clkb net0113 VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0101 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0101 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net088 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net088 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSND4BWP35 D E SDN Q QN VDD VSS
MM25 net0142 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS qf net0126 VSS nch_mac l=35.0n w=110.0n m=1
MM18 qf_x clkb net0126 VSS nch_mac l=35.0n w=110.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net0135 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net0135 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf SDN net0142 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0143 D VSS VSS nch_mac l=35.0n w=110.0n m=1
MM4 qf_x E net0143 VSS nch_mac l=35.0n w=110.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net0159 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0159 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net082 VDD pch_mac l=35.0n w=140.0n m=1
MM16 VDD qf net082 VDD pch_mac l=35.0n w=140.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net0135 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net0135 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x clkb net0103 VDD pch_mac l=35.0n w=140.0n m=1
MM2 net0103 D VDD VDD pch_mac l=35.0n w=140.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHSNDD1BWP35 D E SDN Q QN VDD VSS
MM6 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net090 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net078 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net078 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net090 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net070 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net070 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net061 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net061 VSS nch_mac l=35.0n w=100n m=1
MM7 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0125 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net0125 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net070 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net070 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net0101 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net0101 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNDD2BWP35 D E SDN Q QN VDD VSS
MM7 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net134 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net122 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net122 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net134 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net70 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net70 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net101 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net101 VSS nch_mac l=35.0n w=100n m=1
MM6 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net81 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net81 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net70 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net70 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net57 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net57 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNDD4BWP35 D E SDN Q QN VDD VSS
MM6 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net117 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS qf net108 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net108 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net141 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net141 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf SDN net117 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net85 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net85 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net69 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net69 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net156 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net156 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net141 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net141 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x clkb net129 VDD pch_mac l=35.0n w=260.0n m=1
MM2 net129 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHSNDQD1BWP35 D E SDN Q VDD VSS
MM6 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net0117 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net0105 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0105 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0117 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net057 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net057 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net092 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net092 VSS nch_mac l=35.0n w=100n m=1
MM7 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net068 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net068 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net057 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net057 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net048 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net048 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNDQD2BWP35 D E SDN Q VDD VSS
MM7 clkb E VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net065 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net066 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net066 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net065 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net058 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net058 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net049 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net049 VSS nch_mac l=35.0n w=100n m=1
MM6 clkb E VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0110 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkb net0110 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net058 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net058 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net093 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkbb net093 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNDQD4BWP35 D E SDN Q VDD VSS
MM6 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 VSS qf net129 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkb net129 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net134 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net134 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net142 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkbb net142 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net158 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net158 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkbb net93 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net93 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net134 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net134 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 qf_x clkb net106 VDD pch_mac l=35.0n w=260.0n m=1
MM2 net106 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LHSNQD1BWP35 D E SDN Q VDD VSS
MM22 net073 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net061 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net061 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net073 VSS nch_mac l=35.0n w=240.0n m=1
MM11 net089 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net089 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkb net044 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net044 VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=215.00n m=1
MM2 net0101 D VDD VDD pch_mac l=35.0n w=215.00n m=1
MM3 qf_x clkb net0101 VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net089 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net089 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net080 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net080 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNQD2BWP35 D E SDN Q VDD VSS
MM26 net095 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x E net096 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net096 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net095 VSS nch_mac l=35.0n w=240.0n m=1
MM11 net052 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net052 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net079 VSS nch_mac l=35.0n w=100n m=1
MM19 VSS qf net079 VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=215.00n m=1
MM2 net063 D VDD VDD pch_mac l=35.0n w=215.00n m=1
MM3 qf_x clkb net063 VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net052 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net052 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net043 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x E net043 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LHSNQD4BWP35 D E SDN Q VDD VSS
MM19 VSS qf net93 VSS nch_mac l=35.0n w=110.0n m=1
MM18 qf_x clkb net93 VSS nch_mac l=35.0n w=110.0n m=1
MM12 Q net122 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net122 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net74 D VSS VSS nch_mac l=35.0n w=110.0n m=1
MM4 qf_x E net74 VSS nch_mac l=35.0n w=110.0n m=1
MM0 clkb E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net58 VSS nch_mac l=35.0n w=240.0n m=1
MM37 net58 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x E net133 VDD pch_mac l=35.0n w=140.0n m=1
MM16 VDD qf net133 VDD pch_mac l=35.0n w=140.0n m=1
MM13 Q net122 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net122 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x clkb net110 VDD pch_mac l=35.0n w=140.0n m=1
MM2 net110 D VDD VDD pch_mac l=35.0n w=140.0n m=1
MM1 clkb E VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCND1BWP35 D EN CDN Q QN VDD VSS
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net84 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net84 D net80 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net80 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net112 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net112 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net59 VSS nch_mac l=35.0n w=100n m=1
MM19 net56 qf net59 VSS nch_mac l=35.0n w=100n m=1
MM20 net56 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net127 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net127 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net112 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net112 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net99 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net99 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCND2BWP35 D EN CDN Q QN VDD VSS
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net098 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net098 D net0102 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0102 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0110 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0110 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x EN net0129 VSS nch_mac l=35.0n w=100n m=1
MM19 net0130 qf net0129 VSS nch_mac l=35.0n w=100n m=1
MM20 net0130 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net061 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net061 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0110 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0110 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net089 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net089 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCND4BWP35 D EN CDN Q QN VDD VSS
MM28 net0130 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net098 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net098 qf net097 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x EN net097 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net0130 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net0130 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net073 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net070 D net073 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net070 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM27 net0130 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net0145 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net0145 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net0130 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net0130 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net0114 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net0114 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCNDD1BWP35 D EN CDN Q QN VDD VSS
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net0137 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0137 D net0140 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0140 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net077 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net077 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net0112 VSS nch_mac l=35.0n w=100n m=1
MM19 net0105 qf net0112 VSS nch_mac l=35.0n w=100n m=1
MM20 net0105 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM22 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net092 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net092 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net077 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net077 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net064 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net064 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCNDD2BWP35 D EN CDN Q QN VDD VSS
MM21 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net95 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net95 D net91 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net91 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net127 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net127 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkbb net70 VSS nch_mac l=35.0n w=100n m=1
MM19 net63 qf net70 VSS nch_mac l=35.0n w=100n m=1
MM20 net63 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net142 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net142 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net127 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net127 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net118 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net118 VDD pch_mac l=35.0n w=100n m=1
MM22 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNCNDD4BWP35 D EN CDN Q QN VDD VSS
MM22 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net91 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net163 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net163 qf net166 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkbb net166 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net91 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net91 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net138 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net135 D net138 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net135 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net91 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net106 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net106 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net91 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net91 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net75 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net75 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCNDQD1BWP35 D EN CDN Q VDD VSS
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net80 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net80 D net76 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net76 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net68 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net68 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net59 VSS nch_mac l=35.0n w=100n m=1
MM19 net52 qf net59 VSS nch_mac l=35.0n w=100n m=1
MM20 net52 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM22 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net119 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net119 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net68 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net68 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net95 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net95 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCNDQD2BWP35 D EN CDN Q VDD VSS
MM21 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net0117 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0117 D net0113 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0113 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0105 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0105 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkbb net096 VSS nch_mac l=35.0n w=100n m=1
MM19 net089 qf net096 VSS nch_mac l=35.0n w=100n m=1
MM20 net089 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net080 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net080 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0105 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0105 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net056 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net056 VDD pch_mac l=35.0n w=100n m=1
MM22 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNCNDQD4BWP35 D EN CDN Q VDD VSS
MM22 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net0110 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net0110 qf net0109 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkbb net0109 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net098 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net098 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net089 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net086 D net089 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net086 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net0157 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net0157 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net098 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net098 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net0137 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net0137 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCNQD1BWP35 D EN CDN Q VDD VSS
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net0108 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0108 D net0111 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net0111 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net056 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net056 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net087 VSS nch_mac l=35.0n w=100n m=1
MM19 net080 qf net087 VSS nch_mac l=35.0n w=100n m=1
MM20 net080 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net071 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net071 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net056 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net056 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net047 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net047 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCNQD2BWP35 D EN CDN Q VDD VSS
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net052 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net052 D net056 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net056 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0104 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net0104 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x EN net079 VSS nch_mac l=35.0n w=100n m=1
MM19 net080 qf net079 VSS nch_mac l=35.0n w=100n m=1
MM20 net080 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net088 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net088 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0104 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net0104 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net0119 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net0119 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCNQD4BWP35 D EN CDN Q VDD VSS
MM20 net141 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net141 qf net144 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x EN net144 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net129 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net129 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net124 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net121 D net124 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net121 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net96 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net96 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net129 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net129 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net73 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net73 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCSND1BWP35 D EN CDN SDN Q QN VDD VSS
MM22 net97 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net109 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net109 D net113 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net113 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net97 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net121 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net121 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net140 VSS nch_mac l=35.0n w=100n m=1
MM19 net141 qf net140 VSS nch_mac l=35.0n w=100n m=1
MM20 net141 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net68 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net68 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net121 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net121 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net96 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net96 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSND2BWP35 D EN CDN SDN Q QN VDD VSS
MM26 net085 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 Q net086 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net074 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net074 D net078 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net078 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net085 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net086 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net086 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net0105 VSS nch_mac l=35.0n w=100n m=1
MM19 net0106 qf net0105 VSS nch_mac l=35.0n w=100n m=1
MM20 net0106 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM24 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 Q net086 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0133 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net0133 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net086 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net086 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net0161 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net0161 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSND4BWP35 D EN CDN SDN Q QN VDD VSS
MM25 net0143 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net0195 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net0182 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net0209 qf net0182 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x EN net0209 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net0195 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net0195 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf SDN net0143 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net0203 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0207 D net0203 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net0207 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net0223 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0223 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net0110 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net0195 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net0110 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net0195 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net0195 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net0135 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net0135 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCSNDD1BWP35 D EN CDN SDN Q QN VDD VSS
MM23 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net087 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net092 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net092 D net088 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net088 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net087 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net080 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net080 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net071 VSS nch_mac l=35.0n w=100n m=1
MM19 net064 qf net071 VSS nch_mac l=35.0n w=100n m=1
MM20 net064 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM24 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0143 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net0143 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net080 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net080 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net0115 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net0115 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSNDD2BWP35 D EN CDN SDN Q QN VDD VSS
MM28 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net118 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM23 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 Q net150 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net138 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net138 D net142 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net142 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net118 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net150 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net150 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net169 VSS nch_mac l=35.0n w=100n m=1
MM19 net170 qf net169 VSS nch_mac l=35.0n w=100n m=1
MM20 net170 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM24 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 Q net150 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net81 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net81 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net150 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net150 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 VDD qf net109 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net109 VDD pch_mac l=35.0n w=100n m=1
MM27 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNCSNDD4BWP35 D EN CDN SDN Q QN VDD VSS
MM41 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net72 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net212 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net108 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM19 net108 qf net115 VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkbb net115 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net212 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net212 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf SDN net72 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net139 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net136 D net139 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net136 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net152 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net152 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net212 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net203 VDD pch_mac l=35.0n w=100n m=1
MM16 VDD qf net203 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net212 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net212 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net228 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net228 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCSNDQD1BWP35 D EN CDN SDN Q VDD VSS
MM23 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net121 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net126 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net126 D net122 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net122 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net121 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net114 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net114 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net105 VSS nch_mac l=35.0n w=100n m=1
MM19 net98 qf net105 VSS nch_mac l=35.0n w=100n m=1
MM20 net98 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM14 net57 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM24 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net82 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net82 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net114 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net114 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net57 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSNDQD2BWP35 D EN CDN SDN Q VDD VSS
MM28 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net76 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net81 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net81 D net77 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net77 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net76 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net121 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net121 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkbb net60 VSS nch_mac l=35.0n w=100n m=1
MM19 net53 qf net60 VSS nch_mac l=35.0n w=100n m=1
MM20 net53 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net136 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net136 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net121 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net121 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 VDD qf net112 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net112 VDD pch_mac l=35.0n w=100n m=1
MM27 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNCSNDQD4BWP35 D EN CDN SDN Q VDD VSS
MM28 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 net97 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkb net86 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net86 D net90 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net90 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net97 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net142 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM12 Q net142 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM18 qf_x clkbb net113 VSS nch_mac l=35.0n w=100n m=1
MM19 net114 qf net113 VSS nch_mac l=35.0n w=100n m=1
MM20 net114 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net126 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x clkbb net126 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net142 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 Q net142 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM16 VDD qf net157 VDD pch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net157 VDD pch_mac l=35.0n w=100n m=1
MM27 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNCSNQD1BWP35 D EN CDN SDN Q VDD VSS
MM15 net60 qf net52 VSS nch_mac l=35.0n w=100n m=1
MM22 net72 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net77 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net77 D net73 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net73 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net72 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net105 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net105 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net60 VSS nch_mac l=35.0n w=100n m=1
MM20 net52 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net120 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net120 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net105 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net105 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net100 VDD pch_mac l=35.0n w=100n m=1
MM14 net100 qf VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSNQD2BWP35 D EN CDN SDN Q VDD VSS
MM26 net114 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net119 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net119 D net115 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net115 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net114 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net107 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net107 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x EN net102 VSS nch_mac l=35.0n w=100n m=1
MM20 net95 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM15 net102 qf net95 VSS nch_mac l=35.0n w=100n m=1
MM14 net54 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM25 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net74 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net74 VDD pch_mac l=35.0n w=250.0n m=1
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net107 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net107 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 qf_x clkb net54 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNCSNQD4BWP35 D EN CDN SDN Q VDD VSS
MM15 net66 qf net69 VSS nch_mac l=35.0n w=100n m=1
MM20 net69 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x EN net66 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net174 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net174 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net117 CDN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 net114 D net117 VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net114 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net130 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net130 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net169 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM10 net174 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net169 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net174 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 qf_x CDN VDD VDD pch_mac l=35.0n w=250.0n m=1
MM3 qf_x EN net190 VDD pch_mac l=35.0n w=250.0n m=1
MM2 net190 D VDD VDD pch_mac l=35.0n w=250.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LND1BWP35 D EN Q QN VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net0104 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0104 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 qf_x clkbb net087 VSS nch_mac l=35.0n w=100n m=1
MM6 net087 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net048 VDD pch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net048 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net071 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net071 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LND2BWP35 D EN Q QN VDD VSS
MM6 net77 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net77 VSS nch_mac l=35.0n w=100n m=1
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net58 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net58 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net110 VDD pch_mac l=35.0n w=100n m=1
MM17 net110 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM2 net105 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net105 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LND4BWP35 D EN Q QN VDD VSS
MM21 net114 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM19 qf_x clkbb net114 VSS nch_mac l=35.0n w=100n m=1
MM16 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM15 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x clkb net91 VSS nch_mac l=35.0n w=155.00n m=1
MM3 net91 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 qf_x clkb net75 VDD pch_mac l=35.0n w=100n m=1
MM18 net75 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM17 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net58 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 qf_x clkbb net58 VDD pch_mac l=35.0n w=260.0n m=1
MM4 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNQD1BWP35 D EN Q VDD VSS
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net53 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net53 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 qf_x clkbb net69 VSS nch_mac l=35.0n w=100n m=1
MM6 net69 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM17 qf_x clkb net76 VDD pch_mac l=35.0n w=100n m=1
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net76 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net96 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net96 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNQD2BWP35 D EN Q VDD VSS
MM6 net70 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net70 VSS nch_mac l=35.0n w=100n m=1
MM9 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net90 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net90 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkb net42 VDD pch_mac l=35.0n w=100n m=1
MM17 net42 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM2 net53 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net53 VDD pch_mac l=35.0n w=260.0n m=1
MM10 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNQD4BWP35 D EN Q VDD VSS
MM21 net46 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM19 qf_x clkbb net46 VSS nch_mac l=35.0n w=100n m=1
MM15 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x clkb net59 VSS nch_mac l=35.0n w=155.00n m=1
MM3 net59 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM5 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 qf_x clkb net75 VDD pch_mac l=35.0n w=100n m=1
MM18 net75 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM14 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net94 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 qf_x clkbb net94 VDD pch_mac l=35.0n w=260.0n m=1
MM4 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNSND1BWP35 D EN SDN Q QN VDD VSS
MM15 net092 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net0104 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net0105 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0105 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0104 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net097 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net097 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net092 VSS nch_mac l=35.0n w=100n m=1
MM7 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=230.0n m=1
MM2 net072 D VDD VDD pch_mac l=35.0n w=230.0n m=1
MM3 qf_x EN net072 VDD pch_mac l=35.0n w=230.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net097 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net097 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net049 VDD pch_mac l=35.0n w=100n m=1
MM14 net049 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM6 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNSND2BWP35 D EN SDN Q QN VDD VSS
MM15 net80 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net63 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net64 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net64 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net63 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net56 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net56 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x EN net80 VSS nch_mac l=35.0n w=100n m=1
MM7 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=230.0n m=1
MM2 net112 D VDD VDD pch_mac l=35.0n w=230.0n m=1
MM3 qf_x EN net112 VDD pch_mac l=35.0n w=230.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net56 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net56 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 qf_x clkb net88 VDD pch_mac l=35.0n w=100n m=1
MM14 net88 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM6 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LNSND4BWP35 D EN SDN Q QN VDD VSS
MM25 net76 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net145 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net92 qf VSS VSS nch_mac l=35.0n w=110.0n m=1
MM18 qf_x EN net92 VSS nch_mac l=35.0n w=110.0n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net145 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net145 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf SDN net76 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net69 D VSS VSS nch_mac l=35.0n w=110.0n m=1
MM4 qf_x clkb net69 VSS nch_mac l=35.0n w=110.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net53 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net53 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net160 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net145 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net160 VDD pch_mac l=35.0n w=140.0n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net145 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net145 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x EN net133 VDD pch_mac l=35.0n w=140.0n m=1
MM2 net133 D VDD VDD pch_mac l=35.0n w=140.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNSNDD1BWP35 D EN SDN Q QN VDD VSS
MM15 net59 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net71 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net72 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net72 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net71 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net112 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net112 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net59 VSS nch_mac l=35.0n w=100n m=1
MM7 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net124 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net124 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net112 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net112 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net100 VDD pch_mac l=35.0n w=100n m=1
MM14 net100 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM6 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNSNDD2BWP35 D EN SDN Q QN VDD VSS
MM15 net128 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net116 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net109 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net109 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net116 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net73 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net73 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkbb net128 VSS nch_mac l=35.0n w=100n m=1
MM7 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM19 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net61 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net61 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net73 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net73 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 qf_x clkb net85 VDD pch_mac l=35.0n w=100n m=1
MM14 net85 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM6 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LNSNDD4BWP35 D EN SDN Q QN VDD VSS
MM7 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net168 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net184 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkbb net184 VSS nch_mac l=35.0n w=100n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 Q net81 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net81 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 qf SDN net168 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net161 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net161 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net145 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net145 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net96 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM26 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net96 VDD pch_mac l=35.0n w=100n m=1
MM14 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM13 Q net81 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net81 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x clkbb net69 VDD pch_mac l=35.0n w=260.0n m=1
MM2 net69 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNSNDQD1BWP35 D EN SDN Q VDD VSS
MM15 net085 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net0108 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net0101 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net0101 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net0108 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0109 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net0109 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x clkbb net085 VSS nch_mac l=35.0n w=100n m=1
MM16 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net060 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net060 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0109 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net0109 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net077 VDD pch_mac l=35.0n w=100n m=1
MM14 net077 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM19 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LNSNDQD2BWP35 D EN SDN Q VDD VSS
MM15 net052 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net064 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkb net065 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net065 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net064 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net057 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net057 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x clkbb net052 VSS nch_mac l=35.0n w=100n m=1
MM19 clkb EN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 clkb EN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net0108 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM3 qf_x clkbb net0108 VDD pch_mac l=35.0n w=260.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net057 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net057 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 qf_x clkb net085 VDD pch_mac l=35.0n w=100n m=1
MM14 net085 qf VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNSNDQD4BWP35 D EN SDN Q VDD VSS
MM7 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net097 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM18 qf_x clkbb net097 VSS nch_mac l=35.0n w=100n m=1
MM12 Q net086 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net086 qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net082 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net082 VSS nch_mac l=35.0n w=155.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net066 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net066 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net086 qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM41 net0174 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net0174 VDD pch_mac l=35.0n w=100n m=1
MM13 Q net086 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 qf_x clkbb net0130 VDD pch_mac l=35.0n w=260.0n m=1
MM2 net0130 D VDD VDD pch_mac l=35.0n w=260.0n m=1
MM1 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LNSNQD1BWP35 D EN SDN Q VDD VSS
MM15 net43 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net55 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net56 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net56 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net55 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net48 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 Q net48 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 qf_x EN net43 VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=230.0n m=1
MM2 net99 D VDD VDD pch_mac l=35.0n w=230.0n m=1
MM3 qf_x EN net99 VDD pch_mac l=35.0n w=230.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net48 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 Q net48 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net76 VDD pch_mac l=35.0n w=100n m=1
MM14 net76 qf VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNSNQD2BWP35 D EN SDN Q VDD VSS
MM15 net79 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM22 net104 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=155.00n m=1
MM4 qf_x clkb net92 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net92 D VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 qf SDN net104 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net84 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 Q net84 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM18 qf_x EN net79 VSS nch_mac l=35.0n w=100n m=1
MM21 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=230.0n m=1
MM2 net63 D VDD VDD pch_mac l=35.0n w=230.0n m=1
MM3 qf_x EN net63 VDD pch_mac l=35.0n w=230.0n m=1
MM8 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net84 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Q net84 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM17 qf_x clkb net40 VDD pch_mac l=35.0n w=100n m=1
MM14 net40 qf VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt LNSNQD4BWP35 D EN SDN Q VDD VSS
MM19 net0125 qf VSS VSS nch_mac l=35.0n w=110.0n m=1
MM18 qf_x EN net0125 VSS nch_mac l=35.0n w=110.0n m=1
MM12 Q net0130 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net0130 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net0134 D VSS VSS nch_mac l=35.0n w=110.0n m=1
MM4 qf_x clkb net0134 VSS nch_mac l=35.0n w=110.0n m=1
MM0 clkb EN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 qf SDN net0150 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net0150 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net085 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM40 qf SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 qf_x clkb net085 VDD pch_mac l=35.0n w=140.0n m=1
MM13 Q net0130 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net0130 qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 qf_x EN net097 VDD pch_mac l=35.0n w=140.0n m=1
MM2 net097 D VDD VDD pch_mac l=35.0n w=140.0n m=1
MM1 clkb EN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI222D0BWP35 A B C ZN VDD VSS
MM6 net19 A ZN VSS nch_mac l=35.0n w=140.0n m=1
MM9 net19 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net19 B ZN VSS nch_mac l=35.0n w=140.0n m=1
MM0 net27 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN A net27 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net15 B ZN VDD pch_mac l=35.0n w=170.0n m=1
MM1 ZN A net38 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net15 A ZN VDD pch_mac l=35.0n w=170.0n m=1
MM2 net15 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net38 B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MAOI222D1BWP35 A B C ZN VDD VSS
MM4 ZN A net33 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net33 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net41 A ZN VSS nch_mac l=35.0n w=280.0n m=1
MM9 net41 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net41 B ZN VSS nch_mac l=35.0n w=280.0n m=1
MM7 net16 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A net16 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net25 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net25 A ZN VDD pch_mac l=35.0n w=340.0n m=1
MM5 net25 B ZN VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI222D2BWP35 A B C ZN VDD VSS
MM58 ZN net054 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 net054 net18 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net18 A net27 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net27 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net19 A net18 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net19 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net19 B net18 VSS nch_mac l=35.0n w=280.0n m=1
MM59 ZN net054 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net054 net18 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net58 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net18 A net58 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net43 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net43 A net18 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net43 B net18 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI222D4BWP35 A B C ZN VDD VSS
MM23 ZN net0102 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net54 A net39 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net39 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net47 A net54 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net47 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net47 B net54 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0102 net54 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 ZN net0102 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net14 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net54 A net14 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net23 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net23 A net54 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net23 B net54 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0102 net54 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM5 net044 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN net100 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net100 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net100 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net044 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net100 B1 net026 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net026 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A1 net86 VDD pch_mac l=35.0n w=220.0n m=1
MM2 net86 net100 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 ZN A2 net86 VDD pch_mac l=35.0n w=220.0n m=1
.ends
.subckt MAOI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM6 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net12 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net12 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN net12 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A2 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net47 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net31 net12 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net12 B1 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM58 ZN net057 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net28 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net064 net40 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net057 B1 net064 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net057 B2 net064 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net40 A1 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM59 ZN net057 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net057 B1 net11 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net11 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net40 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net057 net40 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net40 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MAOI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM23 ZN net072 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 net32 A1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net072 B2 net15 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net072 B1 net15 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net15 net32 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 ZN net072 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net32 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net072 net32 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net32 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net51 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net072 B1 net51 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MOAI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 net20 A1 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM3 net20 net24 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net12 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net20 A2 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM5 net24 B1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net36 A1 ZN VDD pch_mac l=35.0n w=170.0n m=1
MM1 VDD A2 net36 VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN net24 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 net24 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net24 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MOAI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM5 net12 B1 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net40 A2 ZN VSS nch_mac l=35.0n w=280.0n m=1
MM6 net36 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net40 net12 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net40 A1 ZN VSS nch_mac l=35.0n w=280.0n m=1
MM7 net12 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net12 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN net12 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 VDD A2 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net24 A1 ZN VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MOAI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM58 ZN net048 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 net048 net12 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net12 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net097 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net048 B1 net097 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM59 ZN net048 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 net048 B1 net0125 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net0125 net12 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net0125 B2 net048 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net28 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net12 A2 net28 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MOAI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM23 ZN net079 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 net56 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net56 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net079 net56 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net079 B1 net68 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net68 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 ZN net079 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net56 A2 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net27 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net40 net56 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net079 B1 net40 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net40 B2 net079 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MUX2D0BWP35 I0 I1 S Z VDD VSS
MM4 net23 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net15 net31 net23 VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net15 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net18 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net31 S VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net15 S net18 VSS nch_mac l=35.0n w=140.0n m=1
MM12 Z net15 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net31 S VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net15 net31 net35 VDD pch_mac l=35.0n w=170.0n m=1
MM0 net47 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 net35 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net15 S net47 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX2D1BWP35 I0 I1 S Z VDD VSS
MM17 net19 net27 net38 VSS nch_mac l=35.0n w=225.00n m=1
MM14 net15 S net38 VSS nch_mac l=35.0n w=225.00n m=1
MM13 net15 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 Z net38 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net19 I0 VSS VSS nch_mac l=35.0n w=225.00n m=1
MM7 net27 S VSS VSS nch_mac l=35.0n w=225.00n m=1
MM16 net19 S net38 VDD pch_mac l=35.0n w=215.00n m=1
MM18 Z net38 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net15 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net19 I0 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM15 net15 net27 net38 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net27 S VDD VDD pch_mac l=35.0n w=310.0n m=1
.ends
.subckt MUX2D2BWP35 I0 I1 S Z VDD VSS
MM58 Z net066 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net43 S VSS VSS nch_mac l=35.0n w=225.00n m=1
MM5 net51 I0 VSS VSS nch_mac l=35.0n w=225.00n m=1
MM13 net55 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net55 S net066 VSS nch_mac l=35.0n w=225.00n m=1
MM17 net51 net43 net066 VSS nch_mac l=35.0n w=225.00n m=1
MM59 Z net066 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net43 S VDD VDD pch_mac l=35.0n w=310.0n m=1
MM15 net55 net43 net066 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net51 I0 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM12 net55 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net51 S net066 VDD pch_mac l=35.0n w=215.00n m=1
.ends
.subckt MUX2D4BWP35 I0 I1 S Z VDD VSS
MM22 net076 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 net080 I0 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM23 Z net095 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM17 net080 net31 net095 VSS nch_mac l=35.0n w=205.00n m=1
MM14 net076 S net095 VSS nch_mac l=35.0n w=205.00n m=1
MM7 net31 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net076 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM21 Z net095 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM59 net080 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net080 S net095 VDD pch_mac l=35.0n w=205.00n m=1
MM15 net076 net31 net095 VDD pch_mac l=35.0n w=205.00n m=1
MM6 net31 S VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MUX2ND0BWP35 I0 I1 S ZN VDD VSS
MM9 ZN S net35 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net23 S VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net35 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN net23 net42 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net42 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN S net10 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net11 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net10 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN net23 net11 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net23 S VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX2ND1BWP35 I0 I1 S ZN VDD VSS
MM0 ZN net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net39 S VSS VSS nch_mac l=35.0n w=225.00n m=1
MM5 net47 I0 VSS VSS nch_mac l=35.0n w=225.00n m=1
MM19 net9 net30 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net51 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net51 S net30 VSS nch_mac l=35.0n w=225.00n m=1
MM17 net47 net39 net30 VSS nch_mac l=35.0n w=225.00n m=1
MM2 ZN net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net39 S VDD VDD pch_mac l=35.0n w=310.0n m=1
MM15 net51 net39 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net47 I0 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM12 net51 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net9 net30 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net47 S net30 VDD pch_mac l=35.0n w=215.00n m=1
.ends
.subckt MUX2ND2BWP35 I0 I1 S ZN VDD VSS
MM38 ZN net093 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM17 net27 net35 net54 VSS nch_mac l=35.0n w=225.00n m=1
MM14 net55 S net54 VSS nch_mac l=35.0n w=225.00n m=1
MM13 net55 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 net093 net54 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net27 I0 VSS VSS nch_mac l=35.0n w=225.00n m=1
MM7 net35 S VSS VSS nch_mac l=35.0n w=225.00n m=1
MM37 ZN net093 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net27 S net54 VDD pch_mac l=35.0n w=215.00n m=1
MM18 net093 net54 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net55 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net27 I0 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM15 net55 net35 net54 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net35 S VDD VDD pch_mac l=35.0n w=310.0n m=1
.ends
.subckt MUX2ND4BWP35 I0 I1 S ZN VDD VSS
MM38 net053 I0 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN net079 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM28 net061 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net31 S VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net061 S net074 VSS nch_mac l=35.0n w=205.00n m=1
MM17 net053 net31 net074 VSS nch_mac l=35.0n w=205.00n m=1
MM29 net079 net074 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM30 net061 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM59 ZN net079 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM37 net053 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM31 net079 net074 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net31 S VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net061 net31 net074 VDD pch_mac l=35.0n w=205.00n m=1
MM16 net053 S net074 VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt MUX2NOPTD2BWP35 I0 I1 S ZN VDD VSS
MM11 net15 I1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM13 net31 S VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net19 I0 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM6 net19 S ZN VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 net15 net31 ZN VDD pch_mac l=35n w=340.0n m=2 nf=1
MM10 net15 I1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM0 net19 I0 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net19 net31 ZN VSS nch_mac l=35n w=280.0n m=2 nf=1
MM9 net15 S ZN VSS nch_mac l=35n w=280.0n m=2 nf=1
MM12 net31 S VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt MUX2NOPTD4BWP35 I0 I1 S ZN VDD VSS
MM11 net15 I1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM13 net080 S VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net19 I0 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM6 net19 S ZN VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 net15 net080 ZN VDD pch_mac l=35n w=340.0n m=4 nf=1
MM10 net15 I1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM0 net19 I0 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 net19 net080 ZN VSS nch_mac l=35n w=280.0n m=4 nf=1
MM9 net15 S ZN VSS nch_mac l=35n w=280.0n m=4 nf=1
MM12 net080 S VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt MUX2NOPTD6BWP35 I0 I1 S ZN VDD VSS
MM11 net15 I1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM13 net31 S VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
MM1 net19 I0 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM6 net19 S ZN VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 net15 net31 ZN VDD pch_mac l=35n w=340.0n m=6 nf=1
MM10 net15 I1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM0 net19 I0 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 net19 net31 ZN VSS nch_mac l=35n w=280.0n m=6 nf=1
MM9 net15 S ZN VSS nch_mac l=35n w=280.0n m=6 nf=1
MM12 net31 S VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
.ends
.subckt MUX2NOPTD8BWP35 I0 I1 S ZN VDD VSS
MM11 net15 I1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM13 net31 S VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net19 I0 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM6 net19 S ZN VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 net15 net31 ZN VDD pch_mac l=35n w=340.0n m=8 nf=1
MM10 net15 I1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM0 net19 I0 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM7 net19 net31 ZN VSS nch_mac l=35n w=280.0n m=8 nf=1
MM9 net15 S ZN VSS nch_mac l=35n w=280.0n m=8 nf=1
MM12 net31 S VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt MUX2OPTD12BWP35 I0 I1 S Z VDD VSS
MM11 Z net48 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM9 net5 S net48 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 net33 net25 net48 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM5 net25 S VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM2 net5 I1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM0 net33 I0 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM10 Z net48 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM8 net5 net25 net48 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM6 net33 S net48 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM4 net25 S VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
MM3 net5 I1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net33 I0 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt MUX2OPTD2BWP35 I0 I1 S Z VDD VSS
MM11 Z net48 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM9 net5 S net48 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 net33 net25 net48 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 net25 S VSS VSS nch_mac l=35n w=140.0n m=1 nf=1
MM2 net5 I1 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM0 net33 I0 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 Z net48 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 net5 net25 net48 VDD pch_mac l=35n w=310.0n m=1 nf=1
MM6 net33 S net48 VDD pch_mac l=35n w=310.0n m=1 nf=1
MM4 net25 S VDD VDD pch_mac l=35n w=170.0n m=1 nf=1
MM3 net5 I1 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net33 I0 VDD VDD pch_mac l=35n w=310.0n m=1 nf=1
.ends
.subckt MUX2OPTD4BWP35 I0 I1 S Z VDD VSS
MM11 Z net48 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM9 net5 S net48 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net33 net25 net48 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 net25 S VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM2 net5 I1 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM0 net33 I0 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM10 Z net48 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 net5 net25 net48 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM6 net33 S net48 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM4 net25 S VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 net5 I1 VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
MM1 net33 I0 VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
.ends
.subckt MUX2OPTD6BWP35 I0 I1 S Z VDD VSS
MM11 Z net48 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM9 net5 S net48 VSS nch_mac l=35n w=280.0n m=3 nf=1
MM7 net33 net25 net48 VSS nch_mac l=35n w=280.0n m=3 nf=1
MM5 net25 S VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net5 I1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM0 net33 I0 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM10 Z net48 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 net5 net25 net48 VDD pch_mac l=35n w=340.0n m=3 nf=1
MM6 net33 S net48 VDD pch_mac l=35n w=340.0n m=3 nf=1
MM4 net25 S VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 net5 I1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net33 I0 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
.ends
.subckt MUX2OPTD8BWP35 I0 I1 S Z VDD VSS
MM11 Z net48 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM9 net5 S net48 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 net33 net25 net48 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM5 net25 S VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net5 I1 VSS VSS nch_mac l=35n w=280.0n m=5 nf=1
MM0 net33 I0 VSS VSS nch_mac l=35n w=280.0n m=5 nf=1
MM10 Z net48 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 net5 net25 net48 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM6 net33 S net48 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM4 net25 S VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 net5 I1 VDD VDD pch_mac l=35n w=340.0n m=5 nf=1
MM1 net33 I0 VDD VDD pch_mac l=35n w=340.0n m=5 nf=1
.ends
.subckt MUX3D0BWP35 I0 I1 I2 S0 S1 Z VDD VSS
MM9 net44 net53 net28 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net57 S1 net28 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net53 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net57 I2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net69 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net77 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 Z net28 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net81 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net81 S0 net44 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net77 net69 net44 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net44 S1 net28 VDD pch_mac l=35.0n w=170.0n m=1
MM10 net57 net53 net28 VDD pch_mac l=35.0n w=170.0n m=1
MM21 net53 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM23 Z net28 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net57 I2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net69 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net81 net69 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net77 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM12 net81 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net77 S0 net44 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX3D1BWP35 I0 I1 I2 S0 S1 Z VDD VSS
MM17 net17 net25 net56 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net13 S0 net56 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net13 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net17 I0 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM7 net25 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net77 S1 net72 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net56 net41 net72 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net77 I2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net41 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 Z net72 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net17 S0 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM12 net13 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net17 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net13 net25 net56 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net25 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net77 net41 net72 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net56 S1 net72 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net77 I2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net41 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM23 Z net72 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MUX3D2BWP35 I0 I1 I2 S0 S1 Z VDD VSS
MM24 Z net087 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM20 net61 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net21 I2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net48 net61 net087 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net21 S1 net087 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net33 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net85 I0 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM13 net89 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net89 S0 net48 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net85 net33 net48 VSS nch_mac l=35.0n w=140.0n m=1
MM25 Z net087 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM21 net61 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net21 I2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net48 S1 net087 VDD pch_mac l=35.0n w=170.0n m=1
MM10 net21 net61 net087 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net33 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net89 net33 net48 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net85 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net89 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net85 S0 net48 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX3D4BWP35 I0 I1 I2 S0 S1 Z VDD VSS
MM58 Z net0146 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM38 net0119 I0 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM40 net0123 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM61 net0127 I2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM17 net0119 net41 net84 VSS nch_mac l=35.0n w=205.00n m=1
MM14 net0123 S0 net84 VSS nch_mac l=35.0n w=205.00n m=1
MM7 net41 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net0127 S1 net0146 VSS nch_mac l=35.0n w=205.00n m=1
MM9 net84 net57 net0146 VSS nch_mac l=35.0n w=205.00n m=1
MM20 net57 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM59 Z net0146 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM37 net0119 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net0127 I2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM39 net0123 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net0119 S0 net84 VDD pch_mac l=35.0n w=205.00n m=1
MM15 net0123 net41 net84 VDD pch_mac l=35.0n w=205.00n m=1
MM6 net41 S0 VDD VDD pch_mac l=35.0n w=150.0n m=1
MM10 net0127 net57 net0146 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net84 S1 net0146 VDD pch_mac l=35.0n w=205.00n m=1
MM21 net57 S1 VDD VDD pch_mac l=35.0n w=150.0n m=1
.ends
.subckt MUX3ND0BWP35 I0 I1 I2 S0 S1 ZN VDD VSS
MM17 net57 net61 net52 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net13 S0 net52 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net13 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net57 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net61 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net65 I2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net33 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net65 S1 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM9 net52 net33 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM16 net57 S0 net52 VDD pch_mac l=35.0n w=170.0n m=1
MM12 net13 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net57 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net13 net61 net52 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net61 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net65 I2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net33 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net65 net33 ZN VDD pch_mac l=35.0n w=170.0n m=1
MM11 net52 S1 ZN VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX3ND1BWP35 I0 I1 I2 S0 S1 ZN VDD VSS
MM4 net0144 net0159 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN net0144 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net40 net17 net0159 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net21 S1 net0159 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net17 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net21 I2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net61 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net69 I0 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM13 net73 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net73 S0 net40 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net69 net61 net40 VSS nch_mac l=35.0n w=140.0n m=1
MM19 net0144 net0159 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN net0144 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net40 S1 net0159 VDD pch_mac l=35.0n w=170.0n m=1
MM10 net21 net17 net0159 VDD pch_mac l=35.0n w=170.0n m=1
MM21 net17 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net21 I2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net61 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net73 net61 net40 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net69 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net73 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net69 S0 net40 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX3ND2BWP35 I0 I1 I2 S0 S1 ZN VDD VSS
MM24 ZN net0157 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM17 net77 net33 net72 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net73 S0 net72 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net73 I1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net77 I0 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM7 net33 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net85 I2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net89 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net85 S1 net96 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net72 net89 net96 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net0157 net96 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 ZN net0157 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net77 S0 net72 VDD pch_mac l=35.0n w=170.0n m=1
MM12 net73 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net77 I0 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net73 net33 net72 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net33 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net85 I2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net89 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net85 net89 net96 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net72 S1 net96 VDD pch_mac l=35.0n w=170.0n m=1
MM19 net0157 net96 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MUX3ND4BWP35 I0 I1 I2 S0 S1 ZN VDD VSS
MM34 net079 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM35 net083 I2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM61 net087 I0 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN net096 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net096 net20 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net44 net21 net20 VSS nch_mac l=35.0n w=205.00n m=1
MM8 net083 S1 net20 VSS nch_mac l=35.0n w=205.00n m=1
MM20 net21 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net77 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net079 S0 net44 VSS nch_mac l=35.0n w=205.00n m=1
MM17 net087 net77 net44 VSS nch_mac l=35.0n w=205.00n m=1
MM38 net079 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM39 net083 I2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM59 ZN net096 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM60 net087 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM19 net096 net20 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net44 S1 net20 VDD pch_mac l=35.0n w=205.00n m=1
MM10 net083 net21 net20 VDD pch_mac l=35.0n w=205.00n m=1
MM21 net21 S1 VDD VDD pch_mac l=35.0n w=150.0n m=1
MM6 net77 S0 VDD VDD pch_mac l=35.0n w=150.0n m=1
MM15 net079 net77 net44 VDD pch_mac l=35.0n w=205.00n m=1
MM16 net087 S0 net44 VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt MUX4D0BWP35 I0 I1 I2 I3 S0 S1 Z VDD VSS
MM26 net10 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net66 I2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 net70 I3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net66 net10 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net70 S0 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net30 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM39 net81 S1 net89 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net109 net30 net89 VSS nch_mac l=35.0n w=140.0n m=1
MM24 net94 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM42 Z net89 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net110 net10 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net94 S0 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net110 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 net10 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM29 net70 I3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net66 I2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net70 net10 net81 VDD pch_mac l=35.0n w=170.0n m=1
MM23 net94 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM35 net30 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net81 net30 net89 VDD pch_mac l=35.0n w=170.0n m=1
MM37 net109 S1 net89 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net110 S0 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net110 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net94 net10 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM41 Z net89 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM31 net66 S0 net81 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX4D1BWP35 I0 I1 I2 I3 S0 S1 Z VDD VSS
MM5 net10 I0 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net26 S0 net17 VSS nch_mac l=35.0n w=270.0n m=1
MM17 net10 net58 net17 VSS nch_mac l=35.0n w=270.0n m=1
MM42 Z net37 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net26 I1 VSS VSS nch_mac l=35.0n w=270.0n m=1
MM40 net17 net90 net37 VSS nch_mac l=35.0n w=140.0n m=1
MM39 net45 S1 net37 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net90 S1 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM34 net50 S0 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net54 net58 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net50 I3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net54 I2 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM26 net58 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 Z net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net26 net58 net17 VDD pch_mac l=35.0n w=275.00n m=1
MM1 net10 I0 VDD VDD pch_mac l=35.0n w=275.00n m=1
MM16 net10 S0 net17 VDD pch_mac l=35.0n w=275.00n m=1
MM37 net17 S1 net37 VDD pch_mac l=35.0n w=170.0n m=1
MM36 net45 net90 net37 VDD pch_mac l=35.0n w=170.0n m=1
MM35 net90 S1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 net54 S0 net45 VDD pch_mac l=35.0n w=275.00n m=1
MM23 net26 I1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM32 net50 net58 net45 VDD pch_mac l=35.0n w=275.00n m=1
MM27 net54 I2 VDD VDD pch_mac l=35.0n w=275.00n m=1
MM29 net50 I3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 net58 S0 VDD VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt MUX4D2BWP35 I0 I1 I2 I3 S0 S1 Z VDD VSS
MM3 Z net0178 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net94 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM26 net10 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net70 I3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net66 I2 VSS VSS nch_mac l=35.0n w=255.00n m=2
MM33 net66 net10 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net70 S0 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net30 S1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM39 net81 S1 net0178 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net109 net30 net0178 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net110 net10 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net94 S0 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net110 I0 VSS VSS nch_mac l=35.0n w=255.00n m=2
MM0 Z net0178 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM25 net10 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 net66 I2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net70 I3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM32 net70 net10 net81 VDD pch_mac l=35.0n w=170.0n m=1
MM35 net30 S1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM36 net81 net30 net0178 VDD pch_mac l=35.0n w=155.00n m=1
MM37 net109 S1 net0178 VDD pch_mac l=35.0n w=155.00n m=1
MM16 net110 S0 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net110 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 net94 net10 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM31 net66 S0 net81 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net94 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt MUX4D4BWP35 I0 I1 I2 I3 S0 S1 Z VDD VSS
MM54 Z net0126 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM55 net172 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM56 net168 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM57 net164 I3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 net160 I2 VSS VSS nch_mac l=35.0n w=255.00n m=2
MM59 net160 net168 net155 VSS nch_mac l=35.0n w=140.0n m=1
MM60 net164 S0 net155 VSS nch_mac l=35.0n w=140.0n m=1
MM61 net148 S1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM62 net155 S1 net0126 VSS nch_mac l=35.0n w=140.0n m=1
MM63 net135 net148 net0126 VSS nch_mac l=35.0n w=140.0n m=1
MM64 net128 net168 net135 VSS nch_mac l=35.0n w=140.0n m=1
MM65 net172 S0 net135 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net128 I0 VSS VSS nch_mac l=35.0n w=255.00n m=2
MM50 net128 S0 net135 VDD pch_mac l=35.0n w=170.0n m=1
MM51 net172 net168 net135 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net128 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM52 net160 S0 net155 VDD pch_mac l=35.0n w=170.0n m=1
MM43 net168 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM44 net160 I2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 net164 I3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM46 net164 net168 net155 VDD pch_mac l=35.0n w=170.0n m=1
MM47 net148 S1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM48 net155 net148 net0126 VDD pch_mac l=35.0n w=155.00n m=1
MM49 net135 S1 net0126 VDD pch_mac l=35.0n w=155.00n m=1
MM42 Z net0126 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM53 net172 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt MUX4ND0BWP35 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MM5 net10 I0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net26 S0 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net10 net58 net17 VSS nch_mac l=35.0n w=140.0n m=1
MM24 net26 I1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 net17 net38 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM39 net45 S1 ZN VSS nch_mac l=35.0n w=140.0n m=1
MM38 net38 S1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM34 net50 S0 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net54 net58 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net50 I3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net54 I2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net58 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 net26 net58 net17 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net10 I0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net10 S0 net17 VDD pch_mac l=35.0n w=170.0n m=1
MM37 net17 S1 ZN VDD pch_mac l=35.0n w=170.0n m=1
MM36 net45 net38 ZN VDD pch_mac l=35.0n w=170.0n m=1
MM35 net38 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM31 net54 S0 net45 VDD pch_mac l=35.0n w=170.0n m=1
MM23 net26 I1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net50 net58 net45 VDD pch_mac l=35.0n w=170.0n m=1
MM27 net54 I2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM29 net50 I3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 net58 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt MUX4ND1BWP35 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MM2 net82 net125 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN net89 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net74 net113 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 net34 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net98 I2 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM30 net102 I3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM33 net98 net34 net113 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net102 S0 net113 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net18 S1 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM39 net74 S1 net89 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net82 net18 net89 VSS nch_mac l=35.0n w=140.0n m=1
MM24 net114 I1 VSS VSS nch_mac l=35.0n w=230.0n m=1
MM17 net126 net34 net125 VSS nch_mac l=35.0n w=230.0n m=1
MM14 net114 S0 net125 VSS nch_mac l=35.0n w=230.0n m=1
MM5 net126 I0 VSS VSS nch_mac l=35.0n w=230.0n m=1
MM3 net74 net113 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net82 net125 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN net89 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 net34 S0 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM29 net102 I3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net98 I2 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM32 net102 net34 net113 VDD pch_mac l=35.0n w=255.00n m=1
MM23 net114 I1 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM31 net98 S0 net113 VDD pch_mac l=35.0n w=175.00n m=1
MM35 net18 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net74 net18 net89 VDD pch_mac l=35.0n w=170.0n m=1
MM37 net82 S1 net89 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net126 S0 net125 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net126 I0 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net114 net34 net125 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt MUX4ND2BWP35 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MM13 ZN net0132 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net18 I0 VSS VSS nch_mac l=35.0n w=230.0n m=1
MM14 net30 S0 net25 VSS nch_mac l=35.0n w=230.0n m=1
MM17 net18 net126 net25 VSS nch_mac l=35.0n w=230.0n m=1
MM24 net30 I1 VSS VSS nch_mac l=35.0n w=230.0n m=1
MM40 net70 net102 net0132 VSS nch_mac l=35.0n w=140.0n m=1
MM39 net66 S1 net0132 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net102 S1 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM34 net54 S0 net49 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net58 net126 net49 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net54 I3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net58 I2 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM26 net126 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net66 net49 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net70 net25 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net0132 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 net30 net126 net25 VDD pch_mac l=35.0n w=295.00n m=1
MM1 net18 I0 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM16 net18 S0 net25 VDD pch_mac l=35.0n w=175.00n m=1
MM37 net70 S1 net0132 VDD pch_mac l=35.0n w=170.0n m=1
MM36 net66 net102 net0132 VDD pch_mac l=35.0n w=170.0n m=1
MM35 net102 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM31 net58 S0 net49 VDD pch_mac l=35.0n w=175.00n m=1
MM23 net30 I1 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM32 net54 net126 net49 VDD pch_mac l=35.0n w=255.00n m=1
MM27 net58 I2 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM29 net54 I3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 net126 S0 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM0 net70 net25 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net66 net49 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt MUX4ND4BWP35 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MM58 ZN net0217 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM61 net0174 I0 VSS VSS nch_mac l=35.0n w=255.00n m=2
MM71 net141 net0204 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net0182 I2 VSS VSS nch_mac l=35.0n w=250.0n m=2
MM67 net0186 I3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM63 net0190 I1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 net161 net0224 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM26 net50 S0 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net0182 net50 net0204 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net0186 S0 net0204 VSS nch_mac l=35.0n w=140.0n m=1
MM38 net142 S1 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM39 net141 S1 net0217 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net161 net142 net0217 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net0174 net50 net0224 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net0190 S0 net0224 VSS nch_mac l=35.0n w=140.0n m=1
MM60 net0174 I0 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM59 ZN net0217 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM70 net141 net0204 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM64 net0182 I2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM66 net0186 I3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM62 net0190 I1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net161 net0224 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM25 net50 S0 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net0186 net50 net0204 VDD pch_mac l=35.0n w=170.0n m=1
MM31 net0182 S0 net0204 VDD pch_mac l=35.0n w=170.0n m=1
MM35 net142 S1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net141 net142 net0217 VDD pch_mac l=35.0n w=170.0n m=1
MM37 net161 S1 net0217 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net0174 S0 net0224 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net0190 net50 net0224 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND2D0BWP35 A1 A2 ZN VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND2D16BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=16
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt ND2D1BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net10 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt ND2D2BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net026 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net026 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt ND2D3BWP35 A1 A2 ZN VDD VSS
MM9 net43 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 ZN A1 net43 VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt ND2D4BWP35 A1 A2 ZN VDD VSS
MM9 net72 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 ZN A1 net72 VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt ND2D6BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=6
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt ND2D8BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=8
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt ND2OPTD12BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM10 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND2OPTD20BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=20 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt ND2OPTD6BWP35 A1 A2 ZN VDD VSS
MM11 net049 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM13 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM12 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 ZN A1 net049 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 net061 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM9 net065 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM6 net069 A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM2 ZN A1 net061 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM3 ZN A1 net069 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM4 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM0 ZN A1 net065 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND2OPTFAD12BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM10 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND2OPTFAD16BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=20 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt ND2OPTFAD20BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=24 nf=1
MM10 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt ND2OPTFAD4BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND2OPTFAD6BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt ND2OPTFAD8BWP35 A1 A2 ZN VDD VSS
MM7 net32 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND2OPTPAD12BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND2OPTPAD16BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=9 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt ND2OPTPAD1BWP35 A1 A2 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt ND2OPTPAD20BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=12 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=20 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt ND2OPTPAD2BWP35 A1 A2 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt ND2OPTPAD4BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=3 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
.ends
.subckt ND2OPTPAD6BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=10 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND2OPTPAD8BWP35 A1 A2 ZN VDD VSS
MM0 net045 A2 VSS VSS nch_mac l=35n w=360.0n m=3 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM7 net045 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt ND2XD0BWP35 A1 A2 ZN VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net14 VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND2XD16BWP35 A1 A2 ZN VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=32
MM4 ZN A1 net14 VSS nch_mac l=35.0n w=280.0n m=32
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=31
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=31
.ends
.subckt ND2XD1BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net10 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND2XD2BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net026 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net026 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=3
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=3
.ends
.subckt ND2XD3BWP35 A1 A2 ZN VDD VSS
MM9 net43 A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 ZN A1 net43 VSS nch_mac l=35.0n w=280.0n m=6
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=5
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=5
MM0 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt ND2XD4BWP35 A1 A2 ZN VDD VSS
MM9 net72 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 ZN A1 net72 VSS nch_mac l=35.0n w=280.0n m=8
MM0 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=7
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=7
.ends
.subckt ND2XD6BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=12
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=11
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=11
.ends
.subckt ND2XD8BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=16
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=15
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=15
.ends
.subckt ND3D0BWP35 A1 A2 A3 ZN VDD VSS
MM0 net7 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN A1 net15 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net15 A2 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND3D16BWP35 A1 A2 A3 ZN VDD VSS
MM0 net7 A3 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 ZN A1 net15 VSS nch_mac l=35.0n w=280.0n m=16
MM9 net15 A2 net7 VSS nch_mac l=35.0n w=280.0n m=16
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt ND3D1BWP35 A1 A2 A3 ZN VDD VSS
MM9 net19 A2 net27 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net19 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net27 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt ND3D2BWP35 A1 A2 A3 ZN VDD VSS
MM18 net031 A2 net023 VSS nch_mac l=35.0n w=280.0n m=1
MM19 ZN A1 net031 VSS nch_mac l=35.0n w=280.0n m=1
MM20 net023 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net40 A2 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM16 ZN A1 net40 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net32 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt ND3D3BWP35 A1 A2 A3 ZN VDD VSS
MM16 ZN A1 net65 VSS nch_mac l=35.0n w=280.0n m=3
MM17 net73 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM15 net65 A2 net73 VSS nch_mac l=35.0n w=280.0n m=3
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt ND3D4BWP35 A1 A2 A3 ZN VDD VSS
MM15 net96 A2 net100 VSS nch_mac l=35.0n w=280.0n m=4
MM17 net100 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 ZN A1 net96 VSS nch_mac l=35.0n w=280.0n m=4
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt ND3D6BWP35 A1 A2 A3 ZN VDD VSS
MM0 net7 A3 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 ZN A1 net15 VSS nch_mac l=35.0n w=280.0n m=6
MM9 net15 A2 net7 VSS nch_mac l=35.0n w=280.0n m=6
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt ND3D8BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=8
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=8
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt ND3OPTD12BWP35 A1 A2 A3 ZN VDD VSS
MM11 net089 A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 net0109 A2 net089 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 net0109 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND3OPTD6BWP35 A1 A2 A3 ZN VDD VSS
MM17 ZN A1 net081 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM11 net089 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM12 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM13 net097 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM14 net0101 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM16 net081 A2 net085 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM19 net069 A2 net065 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM20 net065 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM18 ZN A1 net069 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM15 net085 A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM5 net32 A2 net0101 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 net0109 A2 net089 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM9 net0113 A2 net058 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM6 net0117 A2 net097 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM2 ZN A1 net0109 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM3 ZN A1 net0117 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM4 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM0 ZN A1 net0113 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND3OPTFAD12BWP35 A1 A2 A3 ZN VDD VSS
MM10 net035 A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 net32 A2 net035 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM11 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt ND3OPTFAD16BWP35 A1 A2 A3 ZN VDD VSS
MM10 net035 A3 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM7 net32 A2 net035 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=20 nf=1
MM11 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt ND3OPTFAD4BWP35 A1 A2 A3 ZN VDD VSS
MM10 net035 A3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 net32 A2 net035 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM11 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND3OPTFAD6BWP35 A1 A2 A3 ZN VDD VSS
MM10 net035 A3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 net32 A2 net035 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM11 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt ND3OPTFAD8BWP35 A1 A2 A3 ZN VDD VSS
MM10 net035 A3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM7 net32 A2 net035 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM11 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM9 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND3OPTPAD12BWP35 A1 A2 A3 ZN VDD VSS
MM0 net041 A3 VSS VSS nch_mac l=35n w=350.0n m=4 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=18 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt ND3OPTPAD16BWP35 A1 A2 A3 ZN VDD VSS
MM0 net041 A3 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=24 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt ND3OPTPAD1BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt ND3OPTPAD2BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt ND3OPTPAD4BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
.ends
.subckt ND3OPTPAD6BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=9 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt ND3OPTPAD8BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A1 net045 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM7 net045 A2 net041 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 net041 A3 VSS VSS nch_mac l=35n w=280.0n m=14 nf=1
MM19 ZN A3 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt ND3OPTSAD12BWP35 A1 A2 A3 ZN VDD VSS
MM0 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM1 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM11 net058 A3 VSS VSS nch_mac l=35n w=360.0n m=10 nf=1
MM7 net32 A2 net058 VSS nch_mac l=35n w=360.0n m=12 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=360.0n m=10 nf=1
MM14 ZN A1 VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM13 ZN A2 VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
.ends
.subckt ND3OPTSAD16BWP35 A1 A2 A3 ZN VDD VSS
MM3 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM11 net058 A3 VSS VSS nch_mac l=35n w=360.0n m=14 nf=1
MM0 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net32 A2 net058 VSS nch_mac l=35n w=360.0n m=16 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=360.0n m=14 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
.ends
.subckt ND3OPTSAD4BWP35 A1 A2 A3 ZN VDD VSS
MM3 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM11 net058 A3 VSS VSS nch_mac l=35n w=360.0n m=2 nf=1
MM0 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net32 A2 net058 VSS nch_mac l=35n w=360.0n m=4 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=360.0n m=2 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
.ends
.subckt ND3OPTSAD6BWP35 A1 A2 A3 ZN VDD VSS
MM11 net058 A3 VSS VSS nch_mac l=35n w=360.0n m=4 nf=1
MM3 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net32 A2 net058 VSS nch_mac l=35n w=360.0n m=6 nf=1
MM0 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=360.0n m=4 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
.ends
.subckt ND3OPTSAD8BWP35 A1 A2 A3 ZN VDD VSS
MM3 net058 A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM11 net058 A3 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM0 ZN A1 net32 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 net32 A2 net058 VSS nch_mac l=35n w=360.0n m=8 nf=1
MM2 ZN A1 net32 VSS nch_mac l=35n w=360.0n m=6 nf=1
MM10 ZN A3 VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM8 ZN A2 VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM1 ZN A1 VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
.ends
.subckt ND3XD0BWP35 A1 A2 A3 ZN VDD VSS
MM9 net19 A2 net27 VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net19 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net27 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND3XD16BWP35 A1 A2 A3 ZN VDD VSS
MM15 net40 A2 net32 VSS nch_mac l=35.0n w=280.0n m=32
MM16 ZN A1 net40 VSS nch_mac l=35.0n w=280.0n m=32
MM17 net32 A3 VSS VSS nch_mac l=35.0n w=280.0n m=32
MM0 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=31
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=32
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=31
.ends
.subckt ND3XD1BWP35 A1 A2 A3 ZN VDD VSS
MM0 ZN A1 net032 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net036 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net032 A2 net036 VSS nch_mac l=35.0n w=280.0n m=1
MM16 ZN A1 net65 VSS nch_mac l=35.0n w=280.0n m=1
MM17 net73 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net65 A2 net73 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=2
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=2
.ends
.subckt ND3XD2BWP35 A1 A2 A3 ZN VDD VSS
MM15 net96 A2 net100 VSS nch_mac l=35.0n w=280.0n m=4
MM17 net100 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 ZN A1 net96 VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=3
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=4
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=3
.ends
.subckt ND3XD3BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=6
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=6
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=5
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=6
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=5
.ends
.subckt ND3XD4BWP35 A1 A2 A3 ZN VDD VSS
MM15 net96 A2 net100 VSS nch_mac l=35.0n w=280.0n m=8
MM17 net100 A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM16 ZN A1 net96 VSS nch_mac l=35.0n w=280.0n m=8
MM0 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=7
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=8
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=7
.ends
.subckt ND3XD6BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=12
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=12
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=12
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=11
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=12
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=11
.ends
.subckt ND3XD8BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=16
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=16
MM0 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=15
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=16
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=15
.ends
.subckt ND4D0BWP35 A1 A2 A3 A4 ZN VDD VSS
MM7 net8 A2 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net8 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net16 A3 net20 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net20 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM8 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM12 ZN A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ND4D1BWP35 A1 A2 A3 A4 ZN VDD VSS
MM9 net24 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net28 A3 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net36 A2 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt ND4D2BWP35 A1 A2 A3 A4 ZN VDD VSS
MM9 net123 A4 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net119 A3 net123 VSS nch_mac l=35.0n w=280.0n m=2
MM22 ZN A1 net111 VSS nch_mac l=35.0n w=280.0n m=2
MM23 net111 A2 net119 VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 ZN A4 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt ND4D3BWP35 A1 A2 A3 A4 ZN VDD VSS
MM22 ZN A1 net65 VSS nch_mac l=35.0n w=280.0n m=3
MM23 net65 A2 net57 VSS nch_mac l=35.0n w=280.0n m=3
MM7 net57 A3 net53 VSS nch_mac l=35.0n w=280.0n m=3
MM9 net53 A4 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM12 ZN A4 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM10 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM8 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM11 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt ND4D4BWP35 A1 A2 A3 A4 ZN VDD VSS
MM23 net67 A2 net75 VSS nch_mac l=35.0n w=280.0n m=4
MM22 ZN A1 net67 VSS nch_mac l=35.0n w=280.0n m=4
MM13 net75 A3 net79 VSS nch_mac l=35.0n w=280.0n m=4
MM4 net79 A4 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A4 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt ND4D8BWP35 A1 A2 A3 A4 ZN VDD VSS
MM31 net89 net81 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM23 net105 A2 net97 VSS nch_mac l=35.0n w=280.0n m=1
MM22 net81 A1 net105 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net97 A3 net93 VSS nch_mac l=35.0n w=280.0n m=1
MM25 net93 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM33 ZN net89 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM30 net89 net81 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM26 net81 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 net81 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM28 net81 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net81 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM32 ZN net89 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR2D0BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt NR2D16BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=16
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt NR2D1BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR2D2BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 ZN A1 net034 VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN A1 net034 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net034 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net034 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR2D3BWP35 A1 A2 ZN VDD VSS
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM17 net55 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 ZN A1 net55 VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt NR2D4BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 ZN A1 net38 VDD pch_mac l=35.0n w=340.0n m=4
MM17 net38 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt NR2D6BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=6
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt NR2D8BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=8
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR2OPTD12BWP35 A1 A2 ZN VDD VSS
MM10 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt NR2OPTD20BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=20 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt NR2OPTD6BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM13 net051 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM14 ZN A1 net051 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM15 ZN A1 net047 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM16 net047 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM17 net035 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM18 ZN A1 net035 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM10 net067 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM11 net071 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM9 ZN A1 net067 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM12 ZN A1 net071 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt NR2OPTFAD12BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM12 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM11 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt NR2OPTFAD16BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM12 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt NR2OPTFAD20BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM12 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
MM13 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=20 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=24 nf=1
.ends
.subckt NR2OPTFAD4BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM11 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt NR2OPTFAD6BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM11 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt NR2OPTFAD8BWP35 A1 A2 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM11 net026 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt NR2OPTPAD12BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
.ends
.subckt NR2OPTPAD16BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
.ends
.subckt NR2OPTPAD1BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt NR2OPTPAD20BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=20 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=40 nf=1
.ends
.subckt NR2OPTPAD2BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM19 ZN A1 net021 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM20 net021 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt NR2OPTPAD4BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM21 net032 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM22 ZN A1 net032 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM23 net024 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM24 ZN A1 net024 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM19 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM20 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt NR2OPTPAD6BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM27 ZN A1 net087 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM21 net032 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM22 ZN A1 net032 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM23 net087 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM24 ZN A1 net087 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM25 net088 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM26 ZN A1 net088 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM28 net087 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM19 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM20 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
.ends
.subckt NR2OPTPAD8BWP35 A1 A2 ZN VDD VSS
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net040 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt NR2XD0BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR2XD16BWP35 A1 A2 ZN VDD VSS
MM0 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=32
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=340.0n m=32
.ends
.subckt NR2XD1BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt NR2XD2BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=4
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt NR2XD3BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt NR2XD4BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=8
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR2XD6BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt NR2XD8BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt NR3D0BWP35 A1 A2 A3 ZN VDD VSS
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net18 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net14 A2 net18 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR3D16BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt NR3D1BWP35 A1 A2 A3 ZN VDD VSS
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net036 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN A1 net040 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net040 A2 net036 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net099 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A1 net0103 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net0103 A2 net099 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR3D2BWP35 A1 A2 A3 ZN VDD VSS
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net78 A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN A1 net82 VDD pch_mac l=35.0n w=340.0n m=4
MM11 net82 A2 net78 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt NR3D3BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=6
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt NR3D4BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR3D6BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=12
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=12
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt NR3D8BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt NR3OPTD12BWP35 A1 A2 A3 ZN VDD VSS
MM11 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM10 net37 A3 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM8 ZN A1 net33 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net33 A2 net37 VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt NR3OPTD6BWP35 A1 A2 A3 ZN VDD VSS
MM11 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM15 ZN A1 net043 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM25 net051 A2 net047 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM26 ZN A1 net051 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM23 net087 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM19 net091 A2 net059 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM18 net059 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM24 net047 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM13 net0107 A2 net071 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM10 net044 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM16 net043 A2 net079 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM21 ZN A1 net083 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM22 net083 A2 net087 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM20 ZN A1 net091 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 ZN A1 net040 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM17 net079 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM12 net071 A3 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM14 ZN A1 net0107 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net040 A2 net044 VDD pch_mac l=35n w=340.0n m=1 nf=1
.ends
.subckt NR3OPTFAD12BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM12 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM13 net029 A3 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM11 net026 A2 net029 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=16 nf=1
.ends
.subckt NR3OPTFAD16BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM12 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=20 nf=1
MM13 net029 A3 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM11 net026 A2 net029 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=20 nf=1
.ends
.subckt NR3OPTFAD4BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM12 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM13 net029 A3 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM11 net026 A2 net029 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=6 nf=1
.ends
.subckt NR3OPTFAD6BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM12 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM13 net029 A3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM11 net026 A2 net029 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=8 nf=1
.ends
.subckt NR3OPTFAD8BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM12 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM13 net029 A3 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM11 net026 A2 net029 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 ZN A1 net026 VDD pch_mac l=35n w=340.0n m=12 nf=1
.ends
.subckt NR3OPTPAD12BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=18 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=21 nf=1
.ends
.subckt NR3OPTPAD16BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=24 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
.ends
.subckt NR3OPTPAD1BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
.ends
.subckt NR3OPTPAD2BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=5 nf=1
.ends
.subckt NR3OPTPAD4BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=7 nf=1
.ends
.subckt NR3OPTPAD6BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=10 nf=1
.ends
.subckt NR3OPTPAD8BWP35 A1 A2 A3 ZN VDD VSS
MM10 ZN A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM7 ZN A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 ZN A3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM19 ZN A1 net025 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 net025 A2 net040 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net040 A3 VDD VDD pch_mac l=35n w=340.0n m=14 nf=1
.ends
.subckt NR3XD0BWP35 A1 A2 A3 ZN VDD VSS
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net18 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net14 A2 net18 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR3XD16BWP35 A1 A2 A3 ZN VDD VSS
MM5 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=31
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=32
MM0 net18 A3 VDD VDD pch_mac l=35.0n w=340.0n m=32
MM3 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=32
MM7 net14 A2 net18 VDD pch_mac l=35.0n w=340.0n m=32
.ends
.subckt NR3XD1BWP35 A1 A2 A3 ZN VDD VSS
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM0 net039 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 ZN A1 net043 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net043 A2 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net099 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A1 net0103 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net0103 A2 net099 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR3XD2BWP35 A1 A2 A3 ZN VDD VSS
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM0 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM3 net78 A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 ZN A1 net82 VDD pch_mac l=35.0n w=340.0n m=4
MM11 net82 A2 net78 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt NR3XD3BWP35 A1 A2 A3 ZN VDD VSS
MM4 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=6
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=6
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt NR3XD4BWP35 A1 A2 A3 ZN VDD VSS
MM4 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=8
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=7
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=7
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR3XD6BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=12
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=11
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=11
MM0 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=12
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=12
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt NR3XD8BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=16
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=15
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=15
MM0 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=16
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt NR4D0BWP35 A1 A2 A3 A4 ZN VDD VSS
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net31 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net27 A2 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net35 A3 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A1 net27 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR4D1BWP35 A1 A2 A3 A4 ZN VDD VSS
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net075 A3 net071 VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net067 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net071 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net19 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net23 A2 net15 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net15 A3 net19 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A1 net23 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net067 A2 net075 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt NR4D2BWP35 A1 A2 A3 A4 ZN VDD VSS
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A4 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN A1 net11 VDD pch_mac l=35.0n w=340.0n m=4
MM7 net19 A3 net15 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net11 A2 net19 VDD pch_mac l=35.0n w=340.0n m=4
MM0 net15 A4 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt NR4D3BWP35 A1 A2 A3 A4 ZN VDD VSS
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 ZN A4 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM0 net35 A4 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 net39 A2 net31 VDD pch_mac l=35.0n w=340.0n m=6
MM7 net31 A3 net35 VDD pch_mac l=35.0n w=340.0n m=6
MM4 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt NR4D4BWP35 A1 A2 A3 A4 ZN VDD VSS
MM2 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A4 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 ZN A1 net11 VDD pch_mac l=35.0n w=340.0n m=8
MM7 net19 A3 net15 VDD pch_mac l=35.0n w=340.0n m=8
MM3 net11 A2 net19 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net15 A4 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt NR4D8BWP35 A1 A2 A3 A4 ZN VDD VSS
MM5 ZN net042 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM58 net042 net058 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 net058 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net058 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net058 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net058 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net042 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM59 net042 net058 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM0 net51 A4 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net55 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net47 A3 net51 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net058 A1 net55 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA211D0BWP35 A1 A2 B C Z VDD VSS
MM5 Z net20 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net20 A1 net23 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net20 A2 net23 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net23 B net12 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net12 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 Z net20 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net47 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net20 A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM10 net20 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM11 net20 B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA211D1BWP35 A1 A2 B C Z VDD VSS
MM9 net32 A2 net35 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net32 A1 net35 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net35 B net40 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net40 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net32 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net32 A2 net11 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net32 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net32 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net32 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA211D2BWP35 A1 A2 B C Z VDD VSS
MM5 Z net20 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net12 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net23 B net12 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net20 A1 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net20 A2 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net20 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net20 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net20 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net47 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net20 A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA211D4BWP35 A1 A2 B C Z VDD VSS
MM0 net35 B net060 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net060 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net32 A2 net35 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net32 A1 net35 VSS nch_mac l=35.0n w=280.0n m=2
MM12 net35 B net40 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net40 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net32 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM3 net039 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net32 A2 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net32 A2 net11 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net32 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net32 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net32 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OA21D0BWP35 A1 A2 B Z VDD VSS
MM5 Z net026 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net6 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net026 A2 net6 VSS nch_mac l=35.0n w=140.0n m=1
MM58 net026 A1 net6 VSS nch_mac l=35.0n w=140.0n m=1
MM4 Z net026 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net043 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net026 A1 net043 VDD pch_mac l=35.0n w=170.0n m=1
MM59 net026 B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA21D16BWP35 A1 A2 B Z VDD VSS
MM5 Z net026 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 net6 B VSS VSS nch_mac l=35.0n w=280.0n m=5
MM2 net026 A2 net6 VSS nch_mac l=35.0n w=280.0n m=5
MM58 net026 A1 net6 VSS nch_mac l=35.0n w=280.0n m=5
MM4 Z net026 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM0 net043 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM1 net026 A1 net043 VDD pch_mac l=35.0n w=340.0n m=5
MM59 net026 B VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt OA21D1BWP35 A1 A2 B Z VDD VSS
MM9 net091 A1 net30 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net091 A2 net30 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 Z net091 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net091 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net18 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net091 A1 net18 VDD pch_mac l=35.0n w=340.0n m=1
MM10 Z net091 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA21D2BWP35 A1 A2 B Z VDD VSS
MM6 Z net15 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net18 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net15 A2 net18 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net15 A1 net18 VSS nch_mac l=35.0n w=280.0n m=1
MM10 Z net15 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net15 A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net30 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net15 B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA21D4BWP35 A1 A2 B Z VDD VSS
MM9 net27 A1 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net27 A2 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 Z net27 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net27 A1 net035 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net035 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net27 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 net18 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net27 A1 net18 VDD pch_mac l=35.0n w=340.0n m=1
MM10 Z net27 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OA21D6BWP35 A1 A2 B Z VDD VSS
MM9 net091 A1 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net091 A2 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 Z net091 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM0 net056 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net091 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 net18 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net091 A1 net18 VDD pch_mac l=35.0n w=340.0n m=1
MM10 Z net091 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM1 net091 A1 net056 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA21D8BWP35 A1 A2 B Z VDD VSS
MM9 net091 A1 net30 VSS nch_mac l=35.0n w=280.0n m=3
MM8 net091 A2 net30 VSS nch_mac l=35.0n w=280.0n m=3
MM7 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 Z net091 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM13 net091 B VDD VDD pch_mac l=35.0n w=340.0n m=3
MM12 net18 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM11 net091 A1 net18 VDD pch_mac l=35.0n w=340.0n m=3
MM10 Z net091 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt OA221D0BWP35 A1 A2 B1 B2 C Z VDD VSS
MM3 net56 B2 net44 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net56 B1 net44 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net44 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net53 A1 net56 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net53 A2 net56 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net24 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net53 B2 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net53 C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net53 A1 net28 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net28 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA221D1BWP35 A1 A2 B1 B2 C Z VDD VSS
MM8 net9 A2 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net9 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net12 B1 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net12 B2 net24 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net24 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net40 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A1 net40 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net9 B2 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net44 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net9 C VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA221D2BWP35 A1 A2 B1 B2 C Z VDD VSS
MM13 net44 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net56 B2 net44 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net56 B1 net44 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net53 A1 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 A2 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net53 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net24 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net53 B2 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net53 A1 net28 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net28 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA221D4BWP35 A1 A2 B1 B2 C Z VDD VSS
MM8 net9 A2 net12 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net9 A1 net12 VSS nch_mac l=35.0n w=280.0n m=2
MM2 net12 B1 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM3 net12 B2 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM13 net24 C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 net063 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net083 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net9 B2 net083 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net9 A1 net063 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net40 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A1 net40 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net9 B2 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net44 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM11 net9 C VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt OA222D0BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM13 net37 C2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net37 C1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net22 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net22 A2 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net22 A1 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net25 B1 net37 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net25 B2 net37 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net45 C1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net22 C2 net45 VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net22 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net57 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 net22 A1 net57 VDD pch_mac l=35.0n w=170.0n m=1
MM0 net22 B2 net61 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net61 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA222D1BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM3 net53 B2 net41 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net53 B1 net41 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net50 A1 net53 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net50 A2 net53 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net50 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net41 C1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net41 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net17 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net50 B2 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net50 A1 net21 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net50 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net50 C2 net33 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net33 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA222D2BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM13 net37 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net37 C1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net22 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net22 A2 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net22 A1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net25 B1 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net25 B2 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net45 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net22 C2 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net22 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net57 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net22 A1 net57 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net22 B2 net61 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net61 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA222D4BWP35 A1 A2 B1 B2 C1 C2 Z VDD VSS
MM3 net53 B2 net41 VSS nch_mac l=35.0n w=280.0n m=2
MM2 net53 B1 net41 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net50 A1 net53 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net50 A2 net53 VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net50 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net41 C1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net41 C2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 net052 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net50 A1 net072 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net072 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net50 B2 net052 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net17 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net50 C2 net048 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net50 B2 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net048 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net50 A1 net21 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net50 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net50 C2 net33 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net33 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA22D0BWP35 A1 A2 B1 B2 Z VDD VSS
MM13 net51 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net51 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net52 A2 net51 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net52 A1 net51 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net52 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net15 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net52 B1 net15 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net52 A1 net19 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net19 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net52 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA22D16BWP35 A1 A2 B1 B2 Z VDD VSS
MM13 net51 B2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM12 net51 B1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM9 net52 A2 net51 VSS nch_mac l=35.0n w=280.0n m=5
MM8 net52 A1 net51 VSS nch_mac l=35.0n w=280.0n m=5
MM5 Z net52 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM11 net15 B2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM10 net52 B1 net15 VDD pch_mac l=35.0n w=340.0n m=5
MM7 net52 A1 net19 VDD pch_mac l=35.0n w=340.0n m=5
MM6 net19 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM4 Z net52 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt OA22D1BWP35 A1 A2 B1 B2 Z VDD VSS
MM8 net8 A1 net11 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net8 A2 net11 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net11 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net11 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net8 A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net8 B1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA22D2BWP35 A1 A2 B1 B2 Z VDD VSS
MM5 Z net44 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net47 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net47 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net44 A2 net47 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net44 A1 net47 VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net44 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 net19 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net44 B1 net19 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net44 A1 net23 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net23 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA22D4BWP35 A1 A2 B1 B2 Z VDD VSS
MM8 net8 A1 net11 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net8 A2 net11 VSS nch_mac l=35.0n w=280.0n m=2
MM12 net11 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net11 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net8 B1 net069 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net069 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net057 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net8 A1 net057 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net8 A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net8 B1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OA22D6BWP35 A1 A2 B1 B2 Z VDD VSS
MM8 net8 A1 net11 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net8 A2 net11 VSS nch_mac l=35.0n w=280.0n m=2
MM12 net11 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net11 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM3 net074 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net064 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net8 A1 net064 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net8 B1 net074 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net8 A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net8 B1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt OA22D8BWP35 A1 A2 B1 B2 Z VDD VSS
MM8 net8 A1 net11 VSS nch_mac l=35.0n w=280.0n m=3
MM9 net8 A2 net11 VSS nch_mac l=35.0n w=280.0n m=3
MM12 net11 B1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM13 net11 B2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM6 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM7 net8 A1 net35 VDD pch_mac l=35.0n w=340.0n m=3
MM10 net8 B1 net39 VDD pch_mac l=35.0n w=340.0n m=3
MM11 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt OA31D0BWP35 A1 A2 A3 B Z VDD VSS
MM1 net32 A3 net11 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net32 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net32 A2 net11 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net32 A1 net11 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net11 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net47 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net32 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net51 A2 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net32 A3 net51 VDD pch_mac l=35.0n w=170.0n m=1
MM10 net32 B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA31D1BWP35 A1 A2 A3 B Z VDD VSS
MM13 net43 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net40 A1 net43 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net40 A2 net43 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net40 A3 net43 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net40 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net40 A3 net11 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A2 net15 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net15 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net40 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net40 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA31D2BWP35 A1 A2 A3 B Z VDD VSS
MM5 Z net12 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net12 A3 net15 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net12 A2 net15 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net12 A1 net15 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net15 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net12 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 net12 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net43 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net47 A2 net43 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net12 A3 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA31D4BWP35 A1 A2 A3 B Z VDD VSS
MM13 net43 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net40 A1 net43 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net40 A2 net43 VSS nch_mac l=35.0n w=280.0n m=2
MM1 net40 A3 net43 VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net40 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net40 A3 net043 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net043 A2 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net039 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 A3 net11 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net11 A2 net15 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net15 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net40 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 Z net40 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OA32D0BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM3 net48 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net48 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net45 A1 net48 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net45 A2 net48 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net45 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net45 A3 net48 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net088 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net45 B2 net088 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net45 A3 net16 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net16 A2 net20 VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net45 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 net20 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA32D1BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM1 net9 A3 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net9 A2 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net9 A1 net12 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net12 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net12 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net44 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net9 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net48 A2 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net9 A3 net48 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net9 B2 net52 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net52 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA32D2BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM3 net56 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net56 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net53 A1 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net53 A2 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net53 A3 net56 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net16 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net53 B2 net16 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net53 A3 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net20 A2 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net24 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA32D4BWP35 A1 A2 A3 B1 B2 Z VDD VSS
MM1 net21 A3 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net21 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net21 A2 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net21 A1 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM13 net24 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net24 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 net40 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net21 B2 net40 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net21 A3 net48 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net48 A2 net52 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net52 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net72 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net21 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net76 A2 net72 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net21 A3 net76 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net21 B2 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net60 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA33D0BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM1 net24 A3 net29 VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net24 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net24 A2 net29 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A1 net29 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net29 B3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net29 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net29 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net24 B3 net41 VDD pch_mac l=35.0n w=170.0n m=1
MM12 net41 B2 net45 VDD pch_mac l=35.0n w=170.0n m=1
MM0 net61 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z net24 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net65 A2 net61 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net24 A3 net65 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net45 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OA33D1BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM9 net46 A1 net49 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net46 A2 net49 VSS nch_mac l=35.0n w=280.0n m=1
MM1 net46 A3 net49 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net49 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net49 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net49 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net46 A3 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net13 A2 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net17 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net29 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net33 B2 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net46 B3 net33 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA33D2BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM5 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net29 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net29 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net29 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A3 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A2 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net26 A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 net26 B3 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net45 B2 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net49 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net61 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net65 A2 net61 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net26 A3 net65 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OA33D4BWP35 A1 A2 A3 B1 B2 B3 Z VDD VSS
MM9 net74 A1 net77 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net74 A2 net77 VSS nch_mac l=35.0n w=280.0n m=2
MM1 net74 A3 net77 VSS nch_mac l=35.0n w=280.0n m=2
MM2 net77 B3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net77 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net77 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 Z net74 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM18 net0126 B2 net0130 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net0130 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net17 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net21 A2 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net74 A3 net21 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net74 A3 net41 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net41 A2 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net45 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net29 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net33 B2 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net74 B3 net33 VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z net74 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM19 net74 B3 net0126 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI211D0BWP35 A1 A2 B C ZN VDD VSS
MM58 ZN A2 net39 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 net39 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net24 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net39 B net24 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net23 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A2 net23 VDD pch_mac l=35.0n w=170.0n m=1
MM5 ZN C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI211D1BWP35 A1 A2 B C ZN VDD VSS
MM2 ZN A1 net11 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net11 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net11 B net20 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net20 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A2 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net27 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI211D2BWP35 A1 A2 B C ZN VDD VSS
MM9 net060 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net39 B net060 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net24 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net39 B net24 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net39 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A1 net39 VSS nch_mac l=35.0n w=280.0n m=2
MM3 net032 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN A2 net032 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM5 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net23 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A2 net23 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI211D4BWP35 A1 A2 B C ZN VDD VSS
MM2 ZN A1 net11 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A2 net11 VSS nch_mac l=35.0n w=280.0n m=4
MM6 net11 B net20 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net20 C VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A2 net27 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net27 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI211OPTD6BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM4 ZN A2 net4 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM3 ZN A1 net4 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 net15 C VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM1 net4 B net15 VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt OAI211OPTD8BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM4 ZN A2 net4 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM3 ZN A1 net4 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 net15 C VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM1 net4 B net15 VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt OAI211OPTREPBD12BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=18 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt OAI211OPTREPBD16BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=20 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt OAI211OPTREPBD1BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt OAI211OPTREPBD2BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=3 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt OAI211OPTREPBD4BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt OAI211OPTREPBD6BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=9 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt OAI211OPTREPBD8BWP35 A1 A2 B C ZN VDD VSS
XMP12 net046 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP21 ZN C VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 ZN A1 net046 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN13 net030 C net019 VSS nch_mac l=35n w=280.0n m=10 nf=1
XMN21 net019 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 net019 A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 ZN B net030 VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt OAI211OPTRESAD12BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=12 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=10 nf=1
MM3 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM10 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=12 nf=1
MM4 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=12 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=10 nf=1
.ends
.subckt OAI211OPTRESAD16BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=16 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=14 nf=1
MM4 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM10 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=16 nf=1
MM3 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=16 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=14 nf=1
.ends
.subckt OAI211OPTRESAD2BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=2 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=2 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=2 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=2 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM10 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=2 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt OAI211OPTRESAD3BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=3 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=3 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=3 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=3 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=1 nf=1
MM3 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM4 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=3 nf=1
MM8 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=3 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=1 nf=1
.ends
.subckt OAI211OPTRESAD4BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=4 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=2 nf=1
MM3 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM10 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=4 nf=1
MM4 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=4 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=2 nf=1
.ends
.subckt OAI211OPTRESAD6BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=6 nf=1
MM8 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=4 nf=1
MM3 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM4 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=6 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=4 nf=1
.ends
.subckt OAI211OPTRESAD8BWP35 A1 A2 B C ZN VDD VSS
MM7 ZN B VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM6 ZN C VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM5 net23 A1 VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM0 ZN A2 net23 VDD pch_mac l=35n w=260.0n m=8 nf=1
MM9 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM10 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=8 nf=1
MM4 net030 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM3 ZN B net15 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net15 C net030 VSS nch_mac l=35n w=360.0n m=8 nf=1
MM1 ZN B net15 VSS nch_mac l=35n w=360.0n m=6 nf=1
.ends
.subckt OAI21D0BWP35 A1 A2 B ZN VDD VSS
MM58 ZN A2 net26 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 net26 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net26 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net064 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A1 net064 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI21D16BWP35 A1 A2 B ZN VDD VSS
MM4 net037 net038 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM7 ZN net037 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM2 net038 A1 net10 VSS nch_mac l=35.0n w=280.0n m=2
MM58 net038 A2 net10 VSS nch_mac l=35.0n w=280.0n m=2
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net037 net038 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM6 ZN net037 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net038 A1 net26 VDD pch_mac l=35.0n w=340.0n m=2
MM59 net038 B VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt OAI21D1BWP35 A1 A2 B ZN VDD VSS
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI21D2BWP35 A1 A2 B ZN VDD VSS
MM3 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A2 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A1 net30 VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN A1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net031 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net14 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI21D4BWP35 A1 A2 B ZN VDD VSS
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=4
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=4
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI21D6BWP35 A1 A2 B ZN VDD VSS
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=6
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=6
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=6
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=6
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt OAI21D8BWP35 A1 A2 B ZN VDD VSS
MM7 ZN net037 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net037 net038 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM2 net038 A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM58 net038 A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net037 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM5 net037 net038 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net038 A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 net038 B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI21OPTPBD12BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
.ends
.subckt OAI21OPTPBD16BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
.ends
.subckt OAI21OPTPBD1BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=1 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt OAI21OPTPBD2BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt OAI21OPTPBD4BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt OAI21OPTPBD6BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=6 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt OAI21OPTPBD8BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN21 ZN A2 net026 VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 ZN A1 net026 VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 net026 B VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt OAI21OPTREPBD12BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt OAI21OPTREPBD16BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt OAI21OPTREPBD1BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=1 nf=1
.ends
.subckt OAI21OPTREPBD2BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt OAI21OPTREPBD4BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt OAI21OPTREPBD6BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt OAI21OPTREPBD8BWP35 A1 A2 B ZN VDD VSS
XMP12 ZN A1 net036 VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP31 ZN B VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
XMP11 net036 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
XMN21 net021 A2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN11 net021 A1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
XMN12 ZN B net021 VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt OAI21OPTRESAD12BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net30 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 net30 A2 VSS VSS nch_mac l=35n w=360.0n m=10 nf=1
MM7 net30 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net30 A1 VSS VSS nch_mac l=35n w=360.0n m=12 nf=1
MM0 ZN B net30 VSS nch_mac l=35n w=360.0n m=10 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=12 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=12 nf=1
.ends
.subckt OAI21OPTRESAD16BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net030 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM0 ZN B net030 VSS nch_mac l=35n w=360.0n m=14 nf=1
MM2 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=16 nf=1
MM6 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=14 nf=1
MM7 net030 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=16 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=16 nf=1
.ends
.subckt OAI21OPTRESAD2BWP35 A1 A2 B ZN VDD VSS
MM6 net30 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net30 A1 VSS VSS nch_mac l=35n w=360.0n m=2 nf=1
MM0 ZN B net30 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=2 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=2 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=2 nf=1
.ends
.subckt OAI21OPTRESAD3BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net30 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 net30 A2 VSS VSS nch_mac l=35n w=360.0n m=1 nf=1
MM7 net30 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net30 A1 VSS VSS nch_mac l=35n w=360.0n m=3 nf=1
MM0 ZN B net30 VSS nch_mac l=35n w=360.0n m=1 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=3 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=3 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=3 nf=1
.ends
.subckt OAI21OPTRESAD4BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net30 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 net30 A2 VSS VSS nch_mac l=35n w=360.0n m=2 nf=1
MM7 net30 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net30 A1 VSS VSS nch_mac l=35n w=360.0n m=4 nf=1
MM0 ZN B net30 VSS nch_mac l=35n w=360.0n m=2 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=4 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=4 nf=1
.ends
.subckt OAI21OPTRESAD6BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net30 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 net30 A2 VSS VSS nch_mac l=35n w=360.0n m=4 nf=1
MM7 net30 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net30 A1 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM0 ZN B net30 VSS nch_mac l=35n w=360.0n m=4 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=6 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=6 nf=1
.ends
.subckt OAI21OPTRESAD8BWP35 A1 A2 B ZN VDD VSS
MM1 ZN B net030 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM0 ZN B net030 VSS nch_mac l=35n w=360.0n m=6 nf=1
MM2 net030 A1 VSS VSS nch_mac l=35n w=360.0n m=8 nf=1
MM6 net030 A2 VSS VSS nch_mac l=35n w=360.0n m=6 nf=1
MM7 net030 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 ZN B VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM4 net18 A2 VDD VDD pch_mac l=35n w=260.0n m=8 nf=1
MM3 ZN A1 net18 VDD pch_mac l=35n w=260.0n m=8 nf=1
.ends
.subckt OAI221D0BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM9 net24 B1 net20 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net20 C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A2 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net24 B2 net20 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net40 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B2 net40 VDD pch_mac l=35.0n w=170.0n m=1
MM4 ZN C VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A1 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net44 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI221D1BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM58 ZN A1 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A2 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net36 B2 net40 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net36 B1 net40 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net40 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net16 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net16 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B2 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net20 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI221D2BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM7 net20 C VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net24 B1 net20 VSS nch_mac l=35.0n w=280.0n m=2
MM5 net24 B2 net20 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A2 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A1 net24 VSS nch_mac l=35.0n w=280.0n m=2
MM6 ZN A1 net070 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net070 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net058 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN B2 net058 VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 net40 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B2 net40 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net44 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI221D4BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM11 ZN net13 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net13 net29 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net28 C VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net32 B1 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net32 B2 net28 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net29 A2 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM58 net29 A1 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN net13 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 net13 net29 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net29 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net29 B2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net29 A1 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net60 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI221XD4BWP35 A1 A2 B1 B2 C ZN VDD VSS
MM58 ZN A1 net36 VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A2 net36 VSS nch_mac l=35.0n w=280.0n m=4
MM5 net36 B2 net40 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net36 B1 net40 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net40 C VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net16 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 ZN A1 net16 VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN B2 net20 VDD pch_mac l=35.0n w=340.0n m=4
MM8 net20 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN C VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI222D0BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM7 net45 C2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net45 C1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net53 B2 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A1 net53 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A2 net53 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net53 B1 net45 VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN C2 net13 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net13 C1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net25 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A1 net25 VDD pch_mac l=35.0n w=170.0n m=1
MM3 ZN B2 net29 VDD pch_mac l=35.0n w=170.0n m=1
MM8 net29 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI222D1BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM9 net17 B1 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A2 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A1 net17 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net17 B2 net25 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net25 C1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net25 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net41 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B2 net41 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net45 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net57 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN C2 net57 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI222D2BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM7 net45 C2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net45 C1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net53 B2 net45 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A1 net53 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A2 net53 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net53 B1 net45 VSS nch_mac l=35.0n w=280.0n m=2
MM11 net058 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN A1 net058 VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN B2 net054 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net054 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN C2 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net13 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net25 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN B2 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net29 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN C2 net046 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net046 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI222D4BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM16 net29 C2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net29 C1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net37 B2 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net34 A1 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM12 net34 A2 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM11 net37 B1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM23 ZN net10 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM24 net10 net34 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net34 C2 net53 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net53 C1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 net65 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net34 A1 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM18 net34 B2 net69 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net69 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 ZN net10 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM26 net10 net34 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI222XD4BWP35 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MM7 net45 C2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net45 C1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net53 B2 net45 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A1 net53 VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A2 net53 VSS nch_mac l=35.0n w=280.0n m=4
MM9 net53 B1 net45 VSS nch_mac l=35.0n w=280.0n m=4
MM4 ZN C2 net13 VDD pch_mac l=35.0n w=340.0n m=4
MM6 net13 C1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net25 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 ZN A1 net25 VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN B2 net29 VDD pch_mac l=35.0n w=340.0n m=4
MM8 net29 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM6 net19 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net19 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 net19 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A2 net19 VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN B1 net27 VDD pch_mac l=35.0n w=170.0n m=1
MM5 net27 B2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A1 net35 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net35 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI22D16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM10 ZN net053 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 net053 net062 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM7 net19 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net19 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net062 A1 net19 VSS nch_mac l=35.0n w=280.0n m=2
MM58 net062 A2 net19 VSS nch_mac l=35.0n w=280.0n m=2
MM9 ZN net053 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM8 net053 net062 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM4 net062 B1 net27 VDD pch_mac l=35.0n w=340.0n m=2
MM5 net27 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net062 A1 net35 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt OAI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net23 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net23 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM7 net19 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net19 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A1 net19 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A2 net19 VSS nch_mac l=35.0n w=280.0n m=2
MM3 ZN A1 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net059 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B1 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net051 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net27 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=280.0n m=4
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM20 ZN B1 net031 VDD pch_mac l=35.0n w=340.0n m=4
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI22D6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=6
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=280.0n m=6
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM20 ZN B1 net031 VDD pch_mac l=35.0n w=340.0n m=6
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt OAI22D8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM8 ZN net043 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM3 net043 net048 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM58 net048 A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net048 A1 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 ZN net043 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM20 net048 B1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net043 net048 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net048 A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI22OPTPBD12BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=12 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=24 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=12 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=24 nf=1
.ends
.subckt OAI22OPTPBD16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=16 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=32 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=16 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=32 nf=1
.ends
.subckt OAI22OPTPBD1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=1 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=1 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt OAI22OPTPBD2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt OAI22OPTPBD4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt OAI22OPTPBD6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=12 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=12 nf=1
.ends
.subckt OAI22OPTPBD8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 ZN A1 net042 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM3 net042 A2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM9 ZN B1 net050 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM1 net050 B2 VDD VDD pch_mac l=35n w=340.0n m=16 nf=1
MM2 net022 B2 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
MM5 ZN A2 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM6 ZN A1 net022 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM28 net022 B1 VSS VSS nch_mac l=35n w=280.0n m=16 nf=1
.ends
.subckt OAI31D0BWP35 A1 A2 A3 B ZN VDD VSS
MM8 ZN A3 net27 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A1 net27 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A2 net27 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net27 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net19 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net23 A2 net19 VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A3 net23 VDD pch_mac l=35.0n w=170.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI31D1BWP35 A1 A2 A3 B ZN VDD VSS
MM7 net23 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A2 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A1 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A3 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A3 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net27 A2 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net31 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI31D2BWP35 A1 A2 A3 B ZN VDD VSS
MM8 ZN A3 net27 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A1 net27 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A2 net27 VSS nch_mac l=35.0n w=280.0n m=2
MM7 net27 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net033 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net029 A2 net033 VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A3 net029 VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net19 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net23 A2 net19 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A3 net23 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI31D4BWP35 A1 A2 A3 B ZN VDD VSS
MM7 net23 B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A2 net23 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A1 net23 VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A3 net23 VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A3 net27 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net27 A2 net31 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net31 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OAI32D0BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM4 net28 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net28 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A2 net28 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A1 net28 VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A3 net28 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net36 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 ZN B2 net36 VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A3 net40 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net40 A2 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net44 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI32D1BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM8 ZN A3 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A1 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A2 net32 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net32 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net32 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net16 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net20 A2 net16 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A3 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B2 net24 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net24 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI32D2BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM4 net28 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net28 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A2 net28 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A1 net28 VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A3 net28 VSS nch_mac l=35.0n w=280.0n m=2
MM13 ZN B2 net32 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net32 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net44 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net48 A2 net44 VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN A3 net48 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net56 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B2 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A3 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net60 A2 net64 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net64 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI32D4BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM11 ZN net13 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net13 net33 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net36 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net36 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net33 A2 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM58 net33 A1 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net33 A3 net36 VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net13 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM9 net13 net33 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net52 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net33 B2 net52 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net33 A3 net56 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net56 A2 net60 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net60 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI32XD4BWP35 A1 A2 A3 B1 B2 ZN VDD VSS
MM8 ZN A3 net64 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A1 net64 VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A2 net64 VSS nch_mac l=35.0n w=280.0n m=4
MM7 net64 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net64 B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net20 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN B2 net20 VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN B2 net16 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net16 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net48 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net52 A2 net48 VDD pch_mac l=35.0n w=340.0n m=4
MM0 ZN A3 net52 VDD pch_mac l=35.0n w=340.0n m=4
MM5 ZN B2 net28 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net28 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net40 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN B2 net40 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI33D0BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM10 net41 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A3 net41 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A1 net41 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A2 net41 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net41 B3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net41 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net17 B1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net21 B2 net17 VDD pch_mac l=35.0n w=170.0n m=1
MM9 ZN B3 net21 VDD pch_mac l=35.0n w=170.0n m=1
MM3 net29 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net33 A2 net29 VDD pch_mac l=35.0n w=170.0n m=1
MM0 ZN A3 net33 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OAI33D1BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM7 net29 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net29 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A2 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A1 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A3 net29 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net29 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN A3 net37 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net37 A2 net41 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net41 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B3 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net49 B2 net53 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net53 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI33D2BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM10 net41 B2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 ZN A3 net41 VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A1 net41 VSS nch_mac l=35.0n w=280.0n m=2
MM2 ZN A2 net41 VSS nch_mac l=35.0n w=280.0n m=2
MM4 net41 B3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net41 B1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM11 net055 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net051 B2 net055 VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN B3 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN A3 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net043 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net039 A2 net043 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net17 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net21 B2 net17 VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B3 net21 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net29 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net33 A2 net29 VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A3 net33 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI33D4BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM12 net10 net34 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 ZN net10 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net37 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net37 B3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net34 A2 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM58 net34 A1 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net34 A3 net37 VSS nch_mac l=35.0n w=280.0n m=1
MM10 net37 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net10 net34 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN net10 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net34 A3 net53 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net53 A2 net57 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net57 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net34 B3 net65 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net65 B2 net69 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net69 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OAI33XD4BWP35 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MM7 net29 B1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net29 B3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 ZN A2 net29 VSS nch_mac l=35.0n w=280.0n m=4
MM58 ZN A1 net29 VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A3 net29 VSS nch_mac l=35.0n w=280.0n m=4
MM10 net29 B2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 ZN A3 net37 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net37 A2 net41 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net41 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM9 ZN B3 net49 VDD pch_mac l=35.0n w=340.0n m=4
MM6 net49 B2 net53 VDD pch_mac l=35.0n w=340.0n m=4
MM5 net53 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OD18DCAP16BWP35 VDD VSS
MM58 VSS VDD VSS VSS nch_18_mac l=770.0n w=270.0n m=1
.ends
.subckt OD18DCAP32BWP35 VDD VSS
MM0 VSS VDD VSS VSS nch_18_mac l=1.37u w=270.0n m=1
MM58 VSS VDD VSS VSS nch_18_mac l=1.37u w=270.0n m=1
.ends
.subckt OD18DCAP64BWP35 VDD VSS
MM2 VSS VDD VSS VSS nch_18_mac l=1.67u w=270.0n m=1
MM1 VSS VDD VSS VSS nch_18_mac l=1.67u w=270.0n m=1
MM3 VSS VDD VSS VSS nch_18_mac l=1.67u w=270.0n m=1
MM4 VSS VDD VSS VSS nch_18_mac l=1.67u w=270.0n m=1
.ends
.subckt OR2D0BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OR2D16BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=5
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt OR2D1BWP35 A1 A2 Z VDD VSS
MM9 net6 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net6 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net6 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net25 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net6 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2D2BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2D4BWP35 A1 A2 Z VDD VSS
MM9 net6 A1 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM8 net6 A2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM0 Z net6 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net039 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net6 A1 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net25 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net6 A1 net25 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OR2D6BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net26 A1 net046 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net046 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2D8BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM4 net039 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net027 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net26 A1 net027 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net26 A1 net039 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2XD0BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OR2XD16BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=8
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt OR2XD1BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2XD2BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2XD4BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt OR2XD6BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 net26 A1 net045 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net045 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net26 A1 net054 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net054 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR2XD8BWP35 A1 A2 Z VDD VSS
MM0 Z net26 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net26 A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 Z net26 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 net26 A1 net13 VDD pch_mac l=35.0n w=340.0n m=4
MM7 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OR3D0BWP35 A1 A2 A3 Z VDD VSS
MM4 net7 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net7 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net7 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net7 A3 net31 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net34 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net31 A2 net34 VDD pch_mac l=35.0n w=170.0n m=1
MM1 Z net7 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OR3D16BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM8 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 net11 A1 net30 VDD pch_mac l=35.0n w=340.0n m=5
MM7 net38 A3 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt OR3D1BWP35 A1 A2 A3 Z VDD VSS
MM8 net31 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net31 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net31 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net31 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net18 A2 net10 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net10 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net31 A3 net18 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net31 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3D2BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3D4BWP35 A1 A2 A3 Z VDD VSS
MM8 net31 A1 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM9 net31 A2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM4 net31 A3 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM0 Z net31 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net030 A2 net038 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net038 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net31 A3 net030 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net18 A2 net10 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net10 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net31 A3 net18 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net31 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt OR3D6BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net11 A3 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net051 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net059 A2 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3D8BWP35 A1 A2 A3 Z VDD VSS
MM5 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net11 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM8 net11 A3 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 net11 A1 net30 VDD pch_mac l=35.0n w=340.0n m=3
MM7 net38 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt OR3XD0BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OR3XD16BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM28 net059 A2 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM27 net051 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net11 A1 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM25 net11 A1 net066 VDD pch_mac l=35.0n w=340.0n m=1
MM24 net074 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net066 A2 net074 VDD pch_mac l=35.0n w=340.0n m=1
MM22 net083 A2 net075 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net075 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 net11 A1 net083 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net11 A1 net090 VDD pch_mac l=35.0n w=340.0n m=1
MM18 net098 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net090 A2 net098 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net11 A1 net0102 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net0110 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net0102 A2 net0110 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net0131 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net11 A1 net0115 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net11 A1 net0119 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net0127 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0119 A2 net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net0115 A2 net0131 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 net11 A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3XD1BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3XD2BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3XD4BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net11 A3 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net051 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net059 A2 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR3XD6BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM4 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 net11 A3 net30 VDD pch_mac l=35.0n w=340.0n m=3
MM7 net38 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt OR3XD8BWP35 A1 A2 A3 Z VDD VSS
MM0 Z net11 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net11 A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net11 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 net11 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 net059 A2 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net051 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net11 A1 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net11 A1 net083 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net075 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net083 A2 net075 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net066 A2 net074 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net11 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 net11 A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net074 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net38 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net30 A2 net38 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net11 A1 net066 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR4D0BWP35 A1 A2 A3 A4 Z VDD VSS
MM6 net28 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net28 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net28 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net28 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net28 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net23 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 Z net28 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net27 A3 net19 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net19 A2 net23 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net28 A4 net27 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt OR4D1BWP35 A1 A2 A3 A4 Z VDD VSS
MM4 net24 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net24 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net24 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net24 A4 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net39 A2 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net31 A3 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net35 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR4D2BWP35 A1 A2 A3 A4 Z VDD VSS
MM6 net28 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net28 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net28 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net28 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net23 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net27 A3 net19 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net19 A2 net23 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net28 A4 net27 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR4D4BWP35 A1 A2 A3 A4 Z VDD VSS
MM4 net24 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net24 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net24 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 net24 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net24 A4 net055 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net063 A2 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net055 A3 net063 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net059 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net24 A4 net31 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net39 A2 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net31 A3 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net24 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM5 net35 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt OR4D8BWP35 A1 A2 A3 A4 Z VDD VSS
MM10 net28 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net28 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 net28 A4 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM9 net28 A3 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM4 net28 A2 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM5 net23 A4 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 net27 A2 net19 VDD pch_mac l=35.0n w=340.0n m=3
MM7 net19 A3 net23 VDD pch_mac l=35.0n w=340.0n m=3
MM2 net28 A1 net27 VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt OR4XD1BWP35 A1 A2 A3 A4 Z VDD VSS
MM6 net28 A4 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net28 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net28 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net28 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net23 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net27 A3 net19 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net19 A2 net23 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net28 A4 net27 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCAOI211D0BWP35 A1 A2 B C ZN VDD VSS
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCAOI211D16BWP35 A1 A2 B C ZN VDD VSS
MM12 net094 A1 net083 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net083 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net094 A1 net051 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net076 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 net094 A1 net076 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net051 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN net112 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM4 net112 net094 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM0 net094 C VSS VSS nch_mac l=35.0n w=140.0n m=4
MM3 net094 B VSS VSS nch_mac l=35.0n w=140.0n m=4
MM8 net094 A1 net101 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net101 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net112 net094 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM11 ZN net112 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM1 net136 C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net144 B net136 VDD pch_mac l=35.0n w=340.0n m=4
MM6 net094 A1 net144 VDD pch_mac l=35.0n w=340.0n m=4
MM7 net094 A2 net144 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCAOI211D1BWP35 A1 A2 B C ZN VDD VSS
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN A1 net063 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net063 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=2
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt RCAOI211D2BWP35 A1 A2 B C ZN VDD VSS
MM20 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=3
MM16 ZN A1 net062 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net062 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 ZN A1 net054 VSS nch_mac l=35.0n w=140.0n m=1
MM19 net054 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN A1 net033 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net033 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=4
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=4
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCAOI211D4BWP35 A1 A2 B C ZN VDD VSS
MM16 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=7
MM4 net0101 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 net073 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net090 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN A1 net090 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net081 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net036 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 ZN A1 net036 VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net0101 VSS nch_mac l=35.0n w=140.0n m=1
MM26 net047 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 ZN A1 net047 VSS nch_mac l=35.0n w=140.0n m=1
MM28 ZN A1 net056 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net056 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN A1 net073 VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A1 net081 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=8
MM3 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=8
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=8
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt RCAOI211D6BWP35 A1 A2 B C ZN VDD VSS
MM17 net058 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 ZN A1 net058 VSS nch_mac l=35.0n w=140.0n m=1
MM19 ZN A1 net067 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net067 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 net074 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 ZN A1 net074 VSS nch_mac l=35.0n w=140.0n m=1
MM23 ZN A1 net083 VSS nch_mac l=35.0n w=140.0n m=1
MM24 net083 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 net090 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 ZN A1 net090 VSS nch_mac l=35.0n w=140.0n m=1
MM31 ZN A1 net0119 VSS nch_mac l=35.0n w=140.0n m=1
MM27 ZN A1 net0107 VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A1 net094 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net0107 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 net0114 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 ZN A1 net0114 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0119 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net0126 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM34 ZN A1 net0126 VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN A1 net0151 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net094 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 ZN C VSS VSS nch_mac l=35.0n w=140.0n m=12
MM3 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=11
MM16 net0151 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=12
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=12
MM6 ZN A1 net47 VDD pch_mac l=35.0n w=340.0n m=12
MM7 ZN A2 net47 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt RCAOI211D8BWP35 A1 A2 B C ZN VDD VSS
MM14 net077 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net040 net077 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM12 net077 A1 net094 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net094 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN net040 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM0 net077 C VSS VSS nch_mac l=35.0n w=140.0n m=2
MM3 net077 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net077 A1 net24 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net24 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN net040 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM5 net040 net077 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net39 C VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net47 B net39 VDD pch_mac l=35.0n w=340.0n m=2
MM6 net077 A1 net47 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net077 A2 net47 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt RCAOI21D0BWP35 A1 A2 B ZN VDD VSS
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCAOI21D16BWP35 A1 A2 B ZN VDD VSS
MM16 net070 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 net070 A1 net037 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net037 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net038 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net070 A1 net038 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net070 A1 net053 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net053 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN net061 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net070 A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net061 net070 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM0 net070 B VSS VSS nch_mac l=35.0n w=140.0n m=3
MM8 ZN net061 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM5 net061 net070 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net070 A2 net30 VDD pch_mac l=35.0n w=340.0n m=4
MM3 net070 A1 net30 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCAOI21D1BWP35 A1 A2 B ZN VDD VSS
MM4 net040 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net040 VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt RCAOI21D2BWP35 A1 A2 B ZN VDD VSS
MM16 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=3
MM13 net048 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A1 net048 VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN A1 net044 VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net027 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net027 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net044 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCAOI21D4BWP35 A1 A2 B ZN VDD VSS
MM20 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 ZN A1 net037 VSS nch_mac l=35.0n w=140.0n m=1
MM18 net037 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net042 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 ZN A1 net042 VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN A1 net057 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net057 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net058 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A1 net058 VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A1 net074 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net089 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net074 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net073 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN A1 net073 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net089 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=7
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=8
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt RCAOI21D6BWP35 A1 A2 B ZN VDD VSS
MM32 ZN A1 net051 VSS nch_mac l=35.0n w=140.0n m=1
MM31 net051 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 net052 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 ZN A1 net052 VSS nch_mac l=35.0n w=140.0n m=1
MM28 ZN A1 net067 VSS nch_mac l=35.0n w=140.0n m=1
MM27 net067 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net068 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 ZN A1 net068 VSS nch_mac l=35.0n w=140.0n m=1
MM24 ZN A1 net083 VSS nch_mac l=35.0n w=140.0n m=1
MM23 net083 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 ZN A1 net084 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net084 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net0131 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A1 net0131 VSS nch_mac l=35.0n w=140.0n m=1
MM13 ZN A1 net0116 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net0116 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 ZN A1 net0115 VSS nch_mac l=35.0n w=140.0n m=1
MM15 net0115 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 ZN A1 net0100 VSS nch_mac l=35.0n w=140.0n m=1
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 ZN A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=11
MM18 net0100 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net099 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 ZN A1 net099 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=12
MM6 ZN A2 net30 VDD pch_mac l=35.0n w=340.0n m=12
MM3 ZN A1 net30 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt RCAOI21D8BWP35 A1 A2 B ZN VDD VSS
MM11 net052 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 net042 A1 net052 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net042 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net033 net042 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN net033 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 net7 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net042 A1 net7 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net042 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN net033 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM7 net30 B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net042 A2 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM3 net042 A1 net30 VDD pch_mac l=35.0n w=340.0n m=2
MM5 net033 net042 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt RCAOI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCAOI22D16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM12 net0146 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM68 net0187 B1 net0262 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net067 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net0187 A1 net0174 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net0187 A1 net0206 VSS nch_mac l=35.0n w=140.0n m=1
MM39 net0167 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM38 net0174 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM24 net0206 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net0187 A1 net067 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net0187 B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net0187 A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM52 net0255 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 net0262 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM54 net0187 B1 net0167 VSS nch_mac l=35.0n w=140.0n m=1
MM55 net0187 B1 net0255 VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN net0146 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM13 net0146 net0187 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM3 net0187 A2 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM2 net0187 A1 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 ZN net0146 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt RCAOI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 net054 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net054 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net046 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN B1 net046 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt RCAOI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM4 net084 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net084 VSS nch_mac l=35.0n w=140.0n m=1
MM14 net076 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN A1 net076 VSS nch_mac l=35.0n w=140.0n m=1
MM16 net068 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 ZN B1 net068 VSS nch_mac l=35.0n w=140.0n m=1
MM18 net060 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 ZN B1 net060 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net043 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 ZN A1 net043 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net035 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 ZN B1 net035 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=4
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCAOI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM35 ZN B1 net076 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net076 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM33 net080 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM32 net084 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net088 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 ZN B1 net080 VSS nch_mac l=35.0n w=140.0n m=1
MM29 ZN B1 net084 VSS nch_mac l=35.0n w=140.0n m=1
MM21 ZN A1 net0148 VSS nch_mac l=35.0n w=140.0n m=1
MM22 net0156 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net0152 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM24 net0148 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 ZN A1 net0156 VSS nch_mac l=35.0n w=140.0n m=1
MM26 net0140 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 ZN A1 net0140 VSS nch_mac l=35.0n w=140.0n m=1
MM28 ZN B1 net088 VSS nch_mac l=35.0n w=140.0n m=1
MM20 ZN A1 net0152 VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN A1 net051 VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN A1 net055 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net047 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net051 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net055 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN B1 net071 VSS nch_mac l=35.0n w=140.0n m=1
MM15 ZN B1 net075 VSS nch_mac l=35.0n w=140.0n m=1
MM16 ZN B1 net079 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net071 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net075 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net079 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN A1 net047 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=8
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=8
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt RCAOI22D6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM55 net0114 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM54 ZN B1 net0114 VSS nch_mac l=35.0n w=140.0n m=1
MM47 net096 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM48 ZN A1 net096 VSS nch_mac l=35.0n w=140.0n m=1
MM53 ZN A1 net079 VSS nch_mac l=35.0n w=140.0n m=1
MM49 ZN A1 net087 VSS nch_mac l=35.0n w=140.0n m=1
MM51 ZN A1 net0147 VSS nch_mac l=35.0n w=140.0n m=1
MM52 net079 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM44 ZN A1 net0112 VSS nch_mac l=35.0n w=140.0n m=1
MM46 net0103 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM43 net0112 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 ZN A1 net0116 VSS nch_mac l=35.0n w=140.0n m=1
MM45 ZN A1 net0103 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net0124 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM39 ZN A1 net0159 VSS nch_mac l=35.0n w=140.0n m=1
MM32 net0159 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 ZN A1 net0124 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net0155 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net0147 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM38 ZN A1 net0148 VSS nch_mac l=35.0n w=140.0n m=1
MM36 ZN A1 net0155 VSS nch_mac l=35.0n w=140.0n m=1
MM23 net039 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 net043 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM20 net050 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net051 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 ZN B1 net043 VSS nch_mac l=35.0n w=140.0n m=1
MM13 ZN B1 net074 VSS nch_mac l=35.0n w=140.0n m=1
MM21 ZN B1 net050 VSS nch_mac l=35.0n w=140.0n m=1
MM22 ZN B1 net039 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net074 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 ZN B1 net082 VSS nch_mac l=35.0n w=140.0n m=1
MM16 net082 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM24 net086 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 ZN B1 net086 VSS nch_mac l=35.0n w=140.0n m=1
MM26 ZN B1 net095 VSS nch_mac l=35.0n w=140.0n m=1
MM27 net095 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net0102 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 ZN B1 net0102 VSS nch_mac l=35.0n w=140.0n m=1
MM30 ZN B1 net0111 VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0111 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 ZN B1 net051 VSS nch_mac l=35.0n w=140.0n m=1
MM34 net0148 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM50 net087 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net16 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM42 net0116 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 ZN A2 net39 VDD pch_mac l=35.0n w=340.0n m=12
MM2 ZN A1 net39 VDD pch_mac l=35.0n w=340.0n m=12
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt RCAOI22D8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM12 net16 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 ZN net076 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM13 net086 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net089 A1 net086 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net076 net089 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM15 net089 B1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net071 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net089 B1 net071 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net089 A1 net12 VSS nch_mac l=35.0n w=140.0n m=1
MM10 ZN net076 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM5 net076 net089 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 net089 A2 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net089 A1 net39 VDD pch_mac l=35.0n w=340.0n m=2
MM1 net39 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net39 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt RCIAO21D0BWP35 A1 A2 B ZN VDD VSS
MM6 ZN net035 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net035 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net035 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN B net39 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net39 net035 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net50 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net035 A1 net50 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt RCIAO21D1BWP35 A1 A2 B ZN VDD VSS
MM2 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net051 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM5 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net051 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net051 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN B net27 VDD pch_mac l=35.0n w=340.0n m=2
MM7 net27 net051 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net23 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net051 A1 net23 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCIAO21D2BWP35 A1 A2 B ZN VDD VSS
MM2 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=3
MM6 ZN net27 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM5 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net27 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net27 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net27 A1 net43 VDD pch_mac l=35.0n w=340.0n m=1
MM0 net43 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net39 net27 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM8 ZN B net39 VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCIAO21D4BWP35 A1 A2 B ZN VDD VSS
MM2 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=7
MM6 ZN net055 VSS VSS nch_mac l=35.0n w=140.0n m=8
MM5 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net055 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net055 A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 net055 A1 net27 VDD pch_mac l=35.0n w=340.0n m=2
MM0 net27 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net23 net055 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM8 ZN B net23 VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt RCIAO21D6BWP35 A1 A2 B ZN VDD VSS
MM2 ZN B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 ZN net055 VSS VSS nch_mac l=35.0n w=140.0n m=12
MM5 ZN B VSS VSS nch_mac l=35.0n w=140.0n m=11
MM3 net055 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 net055 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 net055 A1 net27 VDD pch_mac l=35.0n w=340.0n m=3
MM0 net27 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM7 net23 net055 VDD VDD pch_mac l=35.0n w=340.0n m=12
MM8 ZN B net23 VDD pch_mac l=35.0n w=340.0n m=12
.ends
.subckt RCIAO22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM17 net58 A1 net42 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net42 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net46 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN net58 net46 VDD pch_mac l=35.0n w=340.0n m=1
MM2 net46 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net63 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net58 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN B1 net63 VSS nch_mac l=35.0n w=140.0n m=1
MM15 net58 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net58 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
.ends
.subckt RCIAO22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM13 net52 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 ZN net36 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM9 ZN B1 net52 VSS nch_mac l=35.0n w=280.0n m=1
MM15 net36 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net36 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net64 B1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM11 ZN net36 net64 VDD pch_mac l=35.0n w=340.0n m=2
MM2 net64 B2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM16 net59 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net36 A1 net59 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCIAO22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM32 net45 net76 net52 VSS nch_mac l=35.0n w=280.0n m=1
MM33 net52 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM36 ZN net45 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM34 net52 A2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM18 net61 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 net76 B2 net61 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net52 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 ZN net45 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM12 net76 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net76 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net88 A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 net45 A2 net88 VDD pch_mac l=35.0n w=340.0n m=2
MM16 net45 net76 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCIAO22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM16 net049 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net79 net068 net049 VSS nch_mac l=35.0n w=280.0n m=2
MM15 net053 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net049 A2 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM14 net068 B2 net053 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net049 A1 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM9 ZN net79 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net068 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net79 net068 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 net068 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net79 A2 net62 VDD pch_mac l=35.0n w=340.0n m=4
MM2 net62 A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 ZN net79 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCIAO22D6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM16 net049 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net79 net068 net049 VSS nch_mac l=35.0n w=280.0n m=3
MM15 net053 B1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net049 A2 VSS VSS nch_mac l=35.0n w=140.0n m=6
MM14 net068 B2 net053 VSS nch_mac l=35.0n w=280.0n m=1
MM6 net049 A1 VSS VSS nch_mac l=35.0n w=140.0n m=5
MM9 ZN net79 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM12 net068 B1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net79 net068 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM13 net068 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net79 A2 net62 VDD pch_mac l=35.0n w=340.0n m=6
MM2 net62 A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM4 ZN net79 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt RCOAI21D0BWP35 A1 A2 B ZN VDD VSS
MM58 ZN A2 net26 VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 net26 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net26 B VSS VSS nch_mac l=35.0n w=140.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net064 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net064 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI21D16BWP35 A1 A2 B ZN VDD VSS
MM14 net077 A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN net037 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM10 net037 net077 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM2 net077 A1 net10 VSS nch_mac l=35.0n w=140.0n m=4
MM58 net077 A2 net10 VSS nch_mac l=35.0n w=140.0n m=3
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM20 net077 A1 net058 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net077 A1 net073 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net074 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net073 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net077 A1 net074 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net077 A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN net037 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM11 net037 net077 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net058 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM59 net077 B VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt RCOAI21D1BWP35 A1 A2 B ZN VDD VSS
MM6 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=140.0n m=2
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net045 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN A1 net045 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI21D2BWP35 A1 A2 B ZN VDD VSS
MM10 ZN A2 net30 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net30 B VSS VSS nch_mac l=35.0n w=280.0n m=2
MM58 ZN A2 net30 VSS nch_mac l=35.0n w=140.0n m=3
MM2 ZN A1 net30 VSS nch_mac l=35.0n w=140.0n m=4
MM4 ZN A1 net066 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net066 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net053 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A1 net053 VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN A1 net046 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net046 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 ZN A1 net14 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net14 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI21D4BWP35 A1 A2 B ZN VDD VSS
MM18 ZN A2 net10 VSS nch_mac l=35.0n w=140.0n m=7
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=140.0n m=8
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 ZN A1 net065 VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN A1 net094 VDD pch_mac l=35.0n w=340.0n m=1
MM6 net086 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 ZN A1 net086 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net050 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN A1 net085 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net085 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net070 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net070 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net065 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A1 net050 VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN A1 net049 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net049 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net094 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt RCOAI21D6BWP35 A1 A2 B ZN VDD VSS
MM29 ZN A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net10 VSS nch_mac l=35.0n w=140.0n m=12
MM58 ZN A2 net10 VSS nch_mac l=35.0n w=140.0n m=11
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=6
MM28 ZN A1 net067 VDD pch_mac l=35.0n w=340.0n m=1
MM27 net067 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net076 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM25 ZN A1 net076 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net0143 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 ZN A1 net0136 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net0136 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net0127 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 ZN A1 net0127 VDD pch_mac l=35.0n w=340.0n m=1
MM23 ZN A1 net084 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net058 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN A1 net058 VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A1 net0120 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net0120 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 net0111 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN A1 net0111 VDD pch_mac l=35.0n w=340.0n m=1
MM24 net084 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 ZN A1 net0104 VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN A1 net0143 VDD pch_mac l=35.0n w=340.0n m=1
MM20 net0104 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net095 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 ZN A1 net095 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 ZN B VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt RCOAI21D8BWP35 A1 A2 B ZN VDD VSS
MM10 net038 A2 net10 VSS nch_mac l=35.0n w=140.0n m=1
MM6 net037 net038 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN net037 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 net038 A1 net10 VSS nch_mac l=35.0n w=140.0n m=2
MM58 net038 A2 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net10 B VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net058 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net038 A1 net058 VDD pch_mac l=35.0n w=340.0n m=1
MM7 net037 net038 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM8 ZN net037 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM1 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net038 A1 net26 VDD pch_mac l=35.0n w=340.0n m=1
MM59 net038 B VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D0BWP35 A1 A2 B1 B2 ZN VDD VSS
MM6 net19 B1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net19 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 ZN A1 net19 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A2 net19 VSS nch_mac l=35.0n w=140.0n m=1
MM4 ZN B1 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net27 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D16BWP35 A1 A2 B1 B2 ZN VDD VSS
MM23 net0250 A2 net096 VSS nch_mac l=35.0n w=280.0n m=1
MM8 ZN net0237 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 net0237 net0250 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM58 net0250 A2 net096 VSS nch_mac l=35.0n w=140.0n m=3
MM2 net0250 A1 net096 VSS nch_mac l=35.0n w=140.0n m=4
MM6 net096 B1 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM7 net096 B2 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM9 net0250 B1 net0118 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net0118 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net0109 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net0250 B1 net0109 VDD pch_mac l=35.0n w=340.0n m=1
MM13 net0250 B1 net0102 VDD pch_mac l=35.0n w=340.0n m=1
MM14 net0102 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 net090 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net0250 A1 net090 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net0250 A1 net089 VDD pch_mac l=35.0n w=340.0n m=1
MM18 net089 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net074 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net0250 A1 net074 VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN net0237 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM20 net0250 B1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net0237 net0250 VDD VDD pch_mac l=35.0n w=340.0n m=5
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net0250 A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D1BWP35 A1 A2 B1 B2 ZN VDD VSS
MM11 net31 B2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN A2 net31 VSS nch_mac l=35.0n w=140.0n m=1
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=140.0n m=2
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net063 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 ZN A1 net063 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net055 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 ZN B1 net055 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net23 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net23 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D2BWP35 A1 A2 B1 B2 ZN VDD VSS
MM19 ZN A2 net19 VSS nch_mac l=35.0n w=280.0n m=1
MM20 net19 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net19 B2 VSS VSS nch_mac l=35.0n w=140.0n m=3
MM6 net19 B1 VSS VSS nch_mac l=35.0n w=140.0n m=4
MM2 ZN A1 net19 VSS nch_mac l=35.0n w=140.0n m=4
MM58 ZN A2 net19 VSS nch_mac l=35.0n w=140.0n m=3
MM11 net085 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net081 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN A1 net085 VDD pch_mac l=35.0n w=340.0n m=1
MM14 ZN A1 net081 VDD pch_mac l=35.0n w=340.0n m=1
MM15 net073 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN B1 net073 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net065 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN B1 net065 VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net059 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net059 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 ZN B1 net051 VDD pch_mac l=35.0n w=340.0n m=1
MM10 net051 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN B1 net27 VDD pch_mac l=35.0n w=340.0n m=1
MM5 net27 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net35 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net35 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D4BWP35 A1 A2 B1 B2 ZN VDD VSS
MM35 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM36 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=140.0n m=7
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=140.0n m=8
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=140.0n m=8
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=140.0n m=7
MM3 net0104 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net0100 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net096 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net092 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net088 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net084 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net080 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN A1 net080 VDD pch_mac l=35.0n w=340.0n m=1
MM13 ZN A1 net084 VDD pch_mac l=35.0n w=340.0n m=1
MM14 ZN A1 net088 VDD pch_mac l=35.0n w=340.0n m=1
MM15 ZN A1 net092 VDD pch_mac l=35.0n w=340.0n m=1
MM16 ZN A1 net096 VDD pch_mac l=35.0n w=340.0n m=1
MM17 ZN A1 net0100 VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN A1 net0104 VDD pch_mac l=35.0n w=340.0n m=1
MM21 ZN B1 net0111 VDD pch_mac l=35.0n w=340.0n m=1
MM22 ZN B1 net0159 VDD pch_mac l=35.0n w=340.0n m=1
MM23 ZN B1 net0119 VDD pch_mac l=35.0n w=340.0n m=1
MM24 ZN B1 net0151 VDD pch_mac l=35.0n w=340.0n m=1
MM25 ZN B1 net0147 VDD pch_mac l=35.0n w=340.0n m=1
MM26 ZN B1 net0143 VDD pch_mac l=35.0n w=340.0n m=1
MM27 ZN B1 net0139 VDD pch_mac l=35.0n w=340.0n m=1
MM28 net0139 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net0143 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 net0147 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 net0151 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM32 net0119 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net0159 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0111 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 ZN B1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D6BWP35 A1 A2 B1 B2 ZN VDD VSS
MM13 ZN A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net31 B2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM58 ZN A2 net31 VSS nch_mac l=35.0n w=140.0n m=11
MM2 ZN A1 net31 VSS nch_mac l=35.0n w=140.0n m=12
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=140.0n m=12
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=140.0n m=11
MM15 net0261 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 ZN A1 net0261 VDD pch_mac l=35.0n w=340.0n m=1
MM22 net0230 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 ZN A1 net0230 VDD pch_mac l=35.0n w=340.0n m=1
MM24 ZN A1 net0229 VDD pch_mac l=35.0n w=340.0n m=1
MM25 net0229 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net0214 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM27 ZN A1 net0214 VDD pch_mac l=35.0n w=340.0n m=1
MM28 ZN A1 net0197 VDD pch_mac l=35.0n w=340.0n m=1
MM29 net0197 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 net0182 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 ZN A1 net0182 VDD pch_mac l=35.0n w=340.0n m=1
MM32 ZN A1 net0181 VDD pch_mac l=35.0n w=340.0n m=1
MM33 net0181 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM34 net0166 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM35 ZN A1 net0166 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net0246 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM17 ZN A1 net0246 VDD pch_mac l=35.0n w=340.0n m=1
MM18 ZN A1 net0245 VDD pch_mac l=35.0n w=340.0n m=1
MM36 ZN B1 net0165 VDD pch_mac l=35.0n w=340.0n m=1
MM37 net0165 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM38 net0150 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 ZN B1 net0150 VDD pch_mac l=35.0n w=340.0n m=1
MM40 ZN B1 net0149 VDD pch_mac l=35.0n w=340.0n m=1
MM41 net0149 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net0134 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM43 ZN B1 net0134 VDD pch_mac l=35.0n w=340.0n m=1
MM44 ZN B1 net0133 VDD pch_mac l=35.0n w=340.0n m=1
MM45 net0133 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM46 net0118 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM47 ZN B1 net0118 VDD pch_mac l=35.0n w=340.0n m=1
MM48 ZN B1 net0117 VDD pch_mac l=35.0n w=340.0n m=1
MM49 net0117 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 net0102 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM51 ZN B1 net0102 VDD pch_mac l=35.0n w=340.0n m=1
MM52 ZN B1 net0101 VDD pch_mac l=35.0n w=340.0n m=1
MM53 net0101 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 net086 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM55 ZN B1 net086 VDD pch_mac l=35.0n w=340.0n m=1
MM21 net0245 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 ZN B1 net0169 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net0169 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 ZN A1 net0173 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net0173 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 ZN B1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 ZN A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt RCOAI22D8BWP35 A1 A2 B1 B2 ZN VDD VSS
MM13 net0153 A2 net31 VSS nch_mac l=35.0n w=140.0n m=1
MM12 ZN net0140 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM9 net0140 net0153 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM58 net0153 A2 net31 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0153 A1 net31 VSS nch_mac l=35.0n w=140.0n m=2
MM6 net31 B1 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM7 net31 B2 VSS VSS nch_mac l=35.0n w=140.0n m=2
MM11 ZN net0140 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM10 net0140 net0153 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM5 net0153 B1 net0169 VDD pch_mac l=35.0n w=340.0n m=1
MM8 net0169 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net0153 A1 net0173 VDD pch_mac l=35.0n w=340.0n m=1
MM3 net0173 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 net0153 B1 net031 VDD pch_mac l=35.0n w=340.0n m=1
MM19 net031 B2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net15 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net0153 A1 net15 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNARD1BWP35 SI D SE CP CDN Q QN VDD VSS
MM52 net86 SE net154 VSS nch_mac l=35.0n w=140.0n m=1
MM73 net102 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM48 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net102 clkb qf VSS nch_mac l=35.0n w=150.0n m=1
MM69 QN net102 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net125 mq net126 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0211 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net125 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net126 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net150 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net150 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net86 net0211 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM42 net10 net0211 net13 VDD pch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net10 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net102 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0211 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM74 net102 qf_x VDD VDD pch_mac l=35.0n w=140.0n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM41 net13 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net10 SE net74 VDD pch_mac l=35.0n w=255.00n m=1
MM68 net102 clkbb qf VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=140.0n m=1
MM43 net74 D VDD VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNARD2BWP35 SI D SE CP CDN Q QN VDD VSS
MM0 net0110 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 qf_x qf net0110 VSS nch_mac l=35.0n w=280.0n m=1
MM47 net82 net0237 net13 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net85 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net18 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM76 qf_x qf net18 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net82 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net42 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net54 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0237 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net54 mq net42 VSS nch_mac l=35.0n w=120.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net66 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net66 clkb qf VSS nch_mac l=35.0n w=150.0n m=1
MM48 net13 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM73 net66 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 net82 SE net85 VSS nch_mac l=35.0n w=140.0n m=1
MM2 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net13 D VDD VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net101 VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net66 clkbb qf VDD pch_mac l=35.0n w=140.0n m=1
MM44 net158 SE net13 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net101 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net161 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM60 net101 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM74 net66 qf_x VDD VDD pch_mac l=35.0n w=140.0n m=1
MM58 net0237 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM70 QN net66 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 mq_x clkbb net158 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net158 net0237 net161 VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt SDFCNARD4BWP35 SI D SE CP CDN Q QN VDD VSS
MM3 net0354 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x qf net0354 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net86 SE net154 VSS nch_mac l=35.0n w=140.0n m=1
MM73 net102 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM48 net161 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net102 clkb qf VSS nch_mac l=35.0n w=150.0n m=1
MM69 QN net102 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net125 mq net126 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0102 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net125 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net126 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net141 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net141 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net86 net0102 net161 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net10 net0102 net13 VDD pch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net10 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net102 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net0102 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM74 net102 qf_x VDD VDD pch_mac l=35.0n w=140.0n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM41 net13 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net10 SE net161 VDD pch_mac l=35.0n w=255.00n m=1
MM68 net102 clkbb qf VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=140.0n m=1
MM43 net161 D VDD VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCND0BWP35 SI D SE CP CDN Q QN VDD VSS
MM19 net296 SE net228 VSS nch_mac l=35.0n w=100n m=1
MM20 net280 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM22 net156 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM23 net280 clkb qf VSS nch_mac l=35.0n w=150.0n m=1
MM24 QN net280 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM25 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net258 mq net256 VSS nch_mac l=35.0n w=100n m=1
MM27 net264 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM28 mq_x clkbb net258 VSS nch_mac l=35.0n w=100n m=1
MM29 net256 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM30 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 mq_x clkb net296 VSS nch_mac l=35.0n w=165.00n m=1
MM32 qf_x CDN net232 VSS nch_mac l=35.0n w=280.0n m=1
MM33 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM34 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net232 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net228 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM36 net296 net264 net156 VSS nch_mac l=35.0n w=175.00n m=1
MM0 net220 net264 net218 VDD pch_mac l=35.0n w=100n m=1
MM1 mq_x clkbb net220 VDD pch_mac l=35.0n w=230.0n m=1
MM2 QN net280 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net264 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM4 net280 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net158 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 net218 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM7 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net158 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM9 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM11 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net220 SE net156 VDD pch_mac l=35.0n w=275.00n m=1
MM13 net280 clkbb qf VDD pch_mac l=35.0n w=170.0n m=1
MM14 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 mq_x clkb net158 VDD pch_mac l=35.0n w=120.0n m=1
MM16 net156 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM17 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM18 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFCND1BWP35 SI D SE CP CDN Q QN VDD VSS
MM52 net86 SE net154 VSS nch_mac l=35.0n w=100n m=1
MM73 net102 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net102 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net102 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net125 mq net126 VSS nch_mac l=35.0n w=100n m=1
MM57 net0211 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net125 VSS nch_mac l=35.0n w=100n m=1
MM66 net126 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net150 VSS nch_mac l=35.0n w=230.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net150 CDN VSS VSS nch_mac l=35.0n w=230.0n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net86 net0211 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM42 net10 net0211 net13 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net10 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net102 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0211 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM74 net102 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net13 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=335.00n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net10 SE net74 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net102 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net74 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCND2BWP35 SI D SE CP CDN Q QN VDD VSS
MM0 net0110 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 qf_x qf net0110 VSS nch_mac l=35.0n w=245.00n m=1
MM47 net82 net0237 net13 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net85 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net18 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM76 qf_x qf net18 VSS nch_mac l=35.0n w=245.00n m=1
MM46 mq_x clkb net82 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net42 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net54 VSS nch_mac l=35.0n w=100n m=1
MM57 net0237 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net54 mq net42 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net66 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net66 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net13 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM73 net66 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net82 SE net85 VSS nch_mac l=35.0n w=100n m=1
MM2 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net13 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net101 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net66 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM44 net158 SE net13 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=2
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net101 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM41 net161 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net101 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net66 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM58 net0237 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net66 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 mq_x clkbb net158 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net158 net0237 net161 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCND4BWP35 SI D SE CP CDN Q QN VDD VSS
MM3 net0354 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM2 qf_x qf net0354 VSS nch_mac l=35.0n w=245.00n m=1
MM52 net86 SE net154 VSS nch_mac l=35.0n w=100n m=1
MM73 net102 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net161 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net102 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net102 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net125 mq net126 VSS nch_mac l=35.0n w=100n m=1
MM57 net0102 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net125 VSS nch_mac l=35.0n w=100n m=1
MM66 net126 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net141 VSS nch_mac l=35.0n w=245.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net141 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net86 net0102 net161 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
MM4 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM42 net10 net0102 net13 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net10 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net102 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net0102 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM74 net102 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net13 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
MM44 net10 SE net161 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net102 clkbb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net161 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNQARD1BWP35 SI D SE CP CDN Q VDD VSS
MM47 net69 net0225 net89 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net72 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net32 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM76 qf_x qf net32 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net69 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net56 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0225 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net53 mq net56 VSS nch_mac l=35.0n w=120.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 net89 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM52 net69 SE net72 VSS nch_mac l=35.0n w=140.0n m=1
MM7 qf clkb net76 VSS nch_mac l=35.0n w=150.0n m=1
MM5 net76 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net89 D VDD VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net96 VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net145 SE net89 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf clkbb net149 VDD pch_mac l=35.0n w=140.0n m=1
MM61 net96 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net148 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM60 net96 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM58 net0225 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM45 mq_x clkbb net145 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net145 net0225 net148 VDD pch_mac l=35.0n w=140.0n m=1
MM4 net149 qf_x VDD VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt SDFCNQARD2BWP35 SI D SE CP CDN Q VDD VSS
MM3 net89 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x qf net89 VSS nch_mac l=35.0n w=280.0n m=1
MM5 net108 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 qf clkb net108 VSS nch_mac l=35.0n w=150.0n m=1
MM52 net109 SE net112 VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM48 net0220 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net132 mq net133 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0219 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net132 VSS nch_mac l=35.0n w=120.0n m=1
MM66 net133 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net109 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net157 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net157 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net112 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net109 net0219 net0220 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net56 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM42 net25 net0219 net28 VDD pch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkbb net25 VDD pch_mac l=35.0n w=230.0n m=1
MM58 net0219 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM60 net76 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM41 net28 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net76 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM6 qf clkbb net56 VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net25 SE net0220 VDD pch_mac l=35.0n w=255.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net76 VDD pch_mac l=35.0n w=140.0n m=1
MM43 net0220 D VDD VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNQARD4BWP35 SI D SE CP CDN Q VDD VSS
MM47 net69 net0239 net61 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net13 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net17 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM76 qf_x qf net17 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net69 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net41 CDN VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net0239 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net53 mq net41 VSS nch_mac l=35.0n w=120.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM48 net61 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM52 net69 SE net13 VSS nch_mac l=35.0n w=140.0n m=1
MM7 qf clkb net77 VSS nch_mac l=35.0n w=150.0n m=1
MM5 net77 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 qf_x qf net84 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net84 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net61 D VDD VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net104 VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM44 net153 SE net61 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf clkbb net128 VDD pch_mac l=35.0n w=275.00n m=1
MM61 net104 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net137 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM60 net104 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
MM58 net0239 SE VDD VDD pch_mac l=35.0n w=255.00n m=1
MM45 mq_x clkbb net153 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net153 net0239 net137 VDD pch_mac l=35.0n w=140.0n m=1
MM4 net128 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNQD0BWP35 SI D SE CP CDN Q VDD VSS
MM22 net221 net241 net229 VSS nch_mac l=35.0n w=175.00n m=1
MM23 net219 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM24 net259 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM27 qf_x CDN net259 VSS nch_mac l=35.0n w=280.0n m=1
MM28 mq_x clkb net221 VSS nch_mac l=35.0n w=165.00n m=1
MM29 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 net235 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM31 mq_x clkbb net237 VSS nch_mac l=35.0n w=100n m=1
MM32 net241 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM33 net237 mq net235 VSS nch_mac l=35.0n w=100n m=1
MM34 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net229 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM36 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM37 net221 SE net219 VSS nch_mac l=35.0n w=100n m=1
MM38 qf clkb net213 VSS nch_mac l=35.0n w=150.0n m=1
MM39 net213 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM2 net229 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM3 mq_x clkb net157 VDD pch_mac l=35.0n w=120.0n m=1
MM8 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net145 SE net229 VDD pch_mac l=35.0n w=275.00n m=1
MM10 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM12 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 qf clkbb net171 VDD pch_mac l=35.0n w=170.0n m=1
MM14 net157 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net161 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net157 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM18 net241 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM19 mq_x clkbb net145 VDD pch_mac l=35.0n w=230.0n m=1
MM20 net145 net241 net161 VDD pch_mac l=35.0n w=100n m=1
MM21 net171 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFCNQD1BWP35 SI D SE CP CDN Q VDD VSS
MM47 net69 net0225 net89 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net72 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net32 CDN VSS VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=230.0n m=1
MM76 qf_x qf net32 VSS nch_mac l=35.0n w=230.0n m=1
MM46 mq_x clkb net69 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net56 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=100n m=1
MM57 net0225 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net53 mq net56 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 net89 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net69 SE net72 VSS nch_mac l=35.0n w=100n m=1
MM7 qf clkb net76 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net76 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net89 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net96 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net145 SE net89 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf clkbb net149 VDD pch_mac l=35.0n w=120.0n m=1
MM61 net96 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=335.00n m=1
MM41 net148 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net96 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0225 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net145 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net145 net0225 net148 VDD pch_mac l=35.0n w=100n m=1
MM4 net149 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
.ends
.subckt SDFCNQD2BWP35 SI D SE CP CDN Q VDD VSS
MM3 net89 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM2 qf_x qf net89 VSS nch_mac l=35.0n w=245.00n m=1
MM5 net108 qf_x VSS VSS nch_mac l=35.0n w=100n m=1
MM7 qf clkb net108 VSS nch_mac l=35.0n w=100n m=1
MM52 net109 SE net112 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net0220 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net132 mq net133 VSS nch_mac l=35.0n w=100n m=1
MM57 net0219 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net132 VSS nch_mac l=35.0n w=100n m=1
MM66 net133 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net109 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net157 VSS nch_mac l=35.0n w=245.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net157 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM51 net112 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net109 net0219 net0220 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM4 net56 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM42 net25 net0219 net28 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net25 VDD pch_mac l=35.0n w=230.0n m=1
MM58 net0219 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net76 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net28 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net76 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM6 qf clkbb net56 VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
MM44 net25 SE net0220 VDD pch_mac l=35.0n w=275.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net76 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net0220 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCNQD4BWP35 SI D SE CP CDN Q VDD VSS
MM47 net69 net0239 net61 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net13 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net17 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM76 qf_x qf net17 VSS nch_mac l=35.0n w=245.00n m=1
MM46 mq_x clkb net69 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net41 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=100n m=1
MM57 net0239 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net53 mq net41 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM48 net61 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net69 SE net13 VSS nch_mac l=35.0n w=100n m=1
MM7 qf clkb net77 VSS nch_mac l=35.0n w=155.00n m=1
MM5 net77 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x qf net84 VSS nch_mac l=35.0n w=245.00n m=1
MM3 net84 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net61 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net104 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM44 net153 SE net61 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 qf clkbb net128 VDD pch_mac l=35.0n w=120.0n m=1
MM61 net104 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM41 net137 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net104 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0239 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net153 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net153 net0239 net137 VDD pch_mac l=35.0n w=100n m=1
MM4 net128 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SDFCSND0BWP35 SI D SE CP CDN SDN Q QN VDD VSS
MM29 net261 net181 net323 VSS nch_mac l=35.0n w=175.00n m=1
MM30 net259 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM31 net307 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM32 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 qf_x qf net307 VSS nch_mac l=35.0n w=280.0n m=1
MM34 mq_x clkb net261 VSS nch_mac l=35.0n w=165.00n m=1
MM35 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM36 net283 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM37 mq_x clkbb net285 VSS nch_mac l=35.0n w=100n m=1
MM38 net181 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM39 net285 mq net283 VSS nch_mac l=35.0n w=100n m=1
MM40 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 QN net273 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM50 net273 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM59 net323 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM62 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM63 net261 SE net259 VSS nch_mac l=35.0n w=100n m=1
MM73 mq mq_x net253 VSS nch_mac l=35.0n w=280.0n m=1
MM74 net253 SDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM80 net243 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM81 net273 SDN net243 VSS nch_mac l=35.0n w=280.0n m=1
MM8 mq mq_x VDD VDD pch_mac l=35.0n w=300n m=1
MM9 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 qf clkb mq VDD pch_mac l=35.0n w=210.0n m=1
MM11 net323 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM12 mq_x clkb net185 VDD pch_mac l=35.0n w=120.0n m=1
MM13 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM14 net273 clkbb qf VDD pch_mac l=35.0n w=210.0n m=1
MM15 net169 SE net323 VDD pch_mac l=35.0n w=275.00n m=1
MM16 qf_x CDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM19 net185 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM20 mq SDN VDD VDD pch_mac l=35.0n w=210.0n m=1
MM21 net167 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net185 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM23 net181 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM24 QN net273 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 mq_x clkbb net169 VDD pch_mac l=35.0n w=230.0n m=1
MM26 net169 net181 net167 VDD pch_mac l=35.0n w=100n m=1
MM27 net273 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM28 net273 SDN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFCSND1BWP35 SI D SE CP CDN SDN Q QN VDD VSS
MM47 net75 net0253 net0248 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net15 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net19 CDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf net19 VSS nch_mac l=35.0n w=230.0n m=1
MM46 net0231 clkb net75 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net39 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 net0231 clkbb net51 VSS nch_mac l=35.0n w=100n m=1
MM57 net0253 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net51 mq net39 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net0339 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM67 net0339 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net0248 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net75 SE net15 VSS nch_mac l=35.0n w=100n m=1
MM2 mq net0231 net83 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net83 SDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM7 net94 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM6 net0339 SDN net94 VSS nch_mac l=35.0n w=155.00n m=1
MM1 mq net0231 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net0248 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 net0231 clkb net114 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM68 net0339 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM44 net167 SE net0248 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net114 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net147 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net114 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0253 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net0339 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 net0231 clkbb net167 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net167 net0253 net147 VDD pch_mac l=35.0n w=100n m=1
MM4 net0339 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net0339 SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCSND2BWP35 SI D SE CP CDN SDN Q QN VDD VSS
MM6 net0399 SDN net99 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net99 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM3 net103 SDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM2 mq mq_x net103 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net111 SE net171 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net79 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0399 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net0399 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net135 mq net138 VSS nch_mac l=35.0n w=100n m=1
MM57 net0236 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net135 VSS nch_mac l=35.0n w=100n m=1
MM66 net138 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net111 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net167 VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net167 CDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM51 net171 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net111 net0236 net79 VSS nch_mac l=35.0n w=175.00n m=1
MM5 net0399 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0399 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net19 net0236 net22 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net19 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net0399 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM58 net0236 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net78 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net22 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM61 net78 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM44 net19 SE net79 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0399 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net78 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net79 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCSND4BWP35 SI D SE CP CDN SDN Q QN VDD VSS
MM9 qf_x qf net15 VSS nch_mac l=35.0n w=245.00n m=1
MM8 net15 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM47 net91 net0274 net0159 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net39 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net0130 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf net0130 VSS nch_mac l=35.0n w=245.00n m=1
MM46 mq_x clkb net91 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net63 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net75 VSS nch_mac l=35.0n w=100n m=1
MM57 net0274 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net75 mq net63 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM69 QN net0174 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM67 net0174 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net0159 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net91 SE net39 VSS nch_mac l=35.0n w=100n m=1
MM2 mq mq_x net98 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net98 SDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM7 net27 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM6 net0174 SDN net27 VSS nch_mac l=35.0n w=155.00n m=1
MM11 qf_x qf VDD VDD pch_mac l=35.0n w=315.00n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net0159 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net146 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM68 net0174 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM44 net191 SE net0159 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=315.00n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=315.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net146 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net194 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net146 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0274 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net0174 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM45 mq_x clkbb net191 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net191 net0274 net194 VDD pch_mac l=35.0n w=100n m=1
MM4 net0174 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net0174 SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCSNQD0BWP35 SI D SE CP CDN SDN Q VDD VSS
MM28 net278 SDN net302 VSS nch_mac l=35.0n w=280.0n m=1
MM29 net302 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM30 net292 SDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 mq mq_x net292 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net290 SE net234 VSS nch_mac l=35.0n w=100n m=1
MM33 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM34 net228 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM35 net278 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM36 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net260 mq net258 VSS nch_mac l=35.0n w=100n m=1
MM38 net210 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM39 mq_x clkbb net260 VSS nch_mac l=35.0n w=100n m=1
MM40 net258 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM49 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM50 mq_x clkb net290 VSS nch_mac l=35.0n w=165.00n m=1
MM59 qf_x qf net238 VSS nch_mac l=35.0n w=280.0n m=1
MM62 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM63 net238 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 net234 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM70 net290 net210 net228 VSS nch_mac l=35.0n w=175.00n m=1
MM8 net278 SDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net278 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net218 net210 net202 VDD pch_mac l=35.0n w=100n m=1
MM11 mq_x clkbb net218 VDD pch_mac l=35.0n w=230.0n m=1
MM12 net210 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 net206 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM14 net202 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM15 mq SDN VDD VDD pch_mac l=35.0n w=210.0n m=1
MM16 net206 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM17 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 qf_x CDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM20 net218 SE net228 VDD pch_mac l=35.0n w=275.00n m=1
MM21 net278 clkbb qf VDD pch_mac l=35.0n w=210.0n m=1
MM22 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM23 mq_x clkb net206 VDD pch_mac l=35.0n w=120.0n m=1
MM24 net228 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM25 qf clkb mq VDD pch_mac l=35.0n w=210.0n m=1
MM26 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 mq mq_x VDD VDD pch_mac l=35.0n w=300n m=1
.ends
.subckt SDFCSNQD1BWP35 SI D SE CP CDN SDN Q VDD VSS
MM6 net0209 SDN net94 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net94 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM3 net98 SDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM2 mq mq_x net98 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net106 SE net162 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0209 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net137 mq net138 VSS nch_mac l=35.0n w=100n m=1
MM57 net0222 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net137 VSS nch_mac l=35.0n w=100n m=1
MM66 net138 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net106 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net153 VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net153 CDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM51 net162 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net106 net0222 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM5 net0209 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0209 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net18 net0222 net34 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net18 VDD pch_mac l=35.0n w=230.0n m=1
MM58 net0222 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net34 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM44 net18 SE net74 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0209 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net74 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFCSNQD2BWP35 SI D SE CP CDN SDN Q VDD VSS
MM10 net0109 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM11 qf_x qf net0109 VSS nch_mac l=35.0n w=245.00n m=1
MM47 net86 net0245 net130 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net89 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net49 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf net49 VSS nch_mac l=35.0n w=245.00n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net58 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net65 VSS nch_mac l=35.0n w=100n m=1
MM57 net0245 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net65 mq net58 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net0163 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net130 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net86 SE net89 VSS nch_mac l=35.0n w=100n m=1
MM2 mq mq_x net94 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net94 SDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM7 net29 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM6 net0163 SDN net29 VSS nch_mac l=35.0n w=155.00n m=1
MM8 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net130 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net137 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net0163 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM44 net182 SE net130 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=315.00n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=315.00n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net137 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net166 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net137 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0245 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net182 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net182 net0245 net166 VDD pch_mac l=35.0n w=100n m=1
MM4 net0163 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net0163 SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCSNQD4BWP35 SI D SE CP CDN SDN Q VDD VSS
MM8 qf_x qf net0194 VSS nch_mac l=35.0n w=245.00n m=1
MM9 net0194 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 net0223 SDN net102 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net102 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM3 net106 SDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM2 mq mq_x net106 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net114 SE net170 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net0268 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0223 clkb qf VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net145 mq net146 VSS nch_mac l=35.0n w=100n m=1
MM57 net0225 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net145 VSS nch_mac l=35.0n w=100n m=1
MM66 net146 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net114 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net166 VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net166 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM51 net170 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net114 net0225 net0268 VSS nch_mac l=35.0n w=175.00n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net0223 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0223 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net18 net0225 net21 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net18 VDD pch_mac l=35.0n w=230.0n m=1
MM58 net0225 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net73 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net21 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM61 net73 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=315.00n m=2
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=315.00n m=1
MM44 net18 SE net0268 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0223 clkbb qf VDD pch_mac l=35.0n w=160.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net73 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net0268 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFD0BWP35 SI D SE CP Q QN VDD VSS
MM20 net212 net156 net262 VSS nch_mac l=35.0n w=175.00n m=1 nf=1
MM21 net210 SI VSS VSS nch_mac l=35.0n w=100n m=1 nf=1
MM22 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM23 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1 nf=1
MM24 mq_x clkb net212 VSS nch_mac l=35.0n w=175.00n m=1 nf=1
MM25 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM26 net230 mq VSS VSS nch_mac l=35.0n w=100n m=1 nf=1
MM27 net156 SE VSS VSS nch_mac l=35.0n w=120.0n m=1 nf=1
MM28 mq_x clkbb net230 VSS nch_mac l=35.0n w=100n m=1 nf=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM30 net224 clkb qf VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM31 net262 D VSS VSS nch_mac l=35.0n w=175.00n m=1 nf=1
MM32 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1 nf=1
MM33 net212 SE net210 VSS nch_mac l=35.0n w=100n m=1 nf=1
MM34 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM35 QN net224 VSS VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM36 net224 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1 nf=1
MM3 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1 nf=1
MM4 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM5 net262 D VDD VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM6 net142 mq VDD VDD pch_mac l=35.0n w=100n m=1 nf=1
MM7 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1 nf=1
MM8 net224 clkbb qf VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM9 net148 SE net262 VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM10 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1 nf=1
MM11 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM12 net146 SI VDD VDD pch_mac l=35.0n w=100n m=1 nf=1
MM13 net156 SE VDD VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM14 mq_x clkbb net148 VDD pch_mac l=35.0n w=200n m=1 nf=1
MM15 net148 net156 net146 VDD pch_mac l=35.0n w=100n m=1 nf=1
MM16 mq_x clkb net142 VDD pch_mac l=35.0n w=100n m=1 nf=1
MM17 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
MM18 net224 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1 nf=1
MM19 QN net224 VDD VDD pch_mac l=35.0n w=170.0n m=1 nf=1
.ends
.subckt SDFD1BWP35 SI D SE CP Q QN VDD VSS
MM47 net61 net0200 net53 VSS nch_mac l=35.0n w=175.00n m=1 nf=1
MM51 net13 SI VSS VSS nch_mac l=35.0n w=100n m=1 nf=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1 nf=1
MM46 mq_x clkb net61 VSS nch_mac l=35.0n w=175.00n m=1 nf=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM66 net33 mq VSS VSS nch_mac l=35.0n w=100n m=1 nf=1
MM57 net0200 SE VSS VSS nch_mac l=35.0n w=120.0n m=1 nf=1
MM65 mq_x clkbb net33 VSS nch_mac l=35.0n w=100n m=1 nf=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM67 net49 clkb qf VSS nch_mac l=35.0n w=265.00n m=1 nf=1
MM48 net53 D VSS VSS nch_mac l=35.0n w=175.00n m=1 nf=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1 nf=1
MM52 net61 SE net13 VSS nch_mac l=35.0n w=100n m=1 nf=1
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM69 QN net49 VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM73 net49 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1 nf=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM43 net53 D VDD VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM79 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1 nf=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
MM68 net49 clkbb qf VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM44 net125 SE net53 VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1 nf=1
MM41 net128 SI VDD VDD pch_mac l=35.0n w=100n m=1 nf=1
MM58 net0200 SE VDD VDD pch_mac l=35.0n w=275.00n m=1 nf=1
MM45 mq_x clkbb net125 VDD pch_mac l=35.0n w=200n m=1 nf=1
MM42 net125 net0200 net128 VDD pch_mac l=35.0n w=100n m=1 nf=1
MM0 mq_x clkb net0172 VDD pch_mac l=35.0n w=100n m=1 nf=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
MM74 net49 qf_x VDD VDD pch_mac l=35.0n w=330.0n m=1 nf=1
MM70 QN net49 VDD VDD pch_mac l=35.0n w=340.0n m=1 nf=1
.ends
.subckt SDFD2BWP35 SI D SE CP Q QN VDD VSS
MM73 net101 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net101 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net89 SE net92 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net0268 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net101 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 mq_x clkbb net112 VSS nch_mac l=35.0n w=100n m=1
MM57 net0196 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM66 net112 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net89 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net92 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net89 net0196 net0268 VSS nch_mac l=35.0n w=175.00n m=1
MM70 QN net101 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net101 qf_x VDD VDD pch_mac l=35.0n w=335.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 mq_x clkb net0107 VDD pch_mac l=35.0n w=100n m=1
MM42 net25 net0196 net37 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net25 VDD pch_mac l=35.0n w=200n m=1
MM58 net0196 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM41 net37 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net25 SE net0268 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net101 clkbb qf VDD pch_mac l=35.0n w=285.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 net0107 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM43 net0268 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFD4BWP35 SI D SE CP Q QN VDD VSS
MM47 net61 net0200 net104 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net64 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM46 mq_x clkb net61 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net33 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net0200 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 mq_x clkbb net33 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM67 net49 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM48 net104 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM52 net61 SE net64 VSS nch_mac l=35.0n w=100n m=1
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net49 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM73 net49 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM43 net104 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 net0172 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM68 net49 clkbb qf VDD pch_mac l=35.0n w=285.00n m=1
MM44 net125 SE net104 VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM41 net113 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM58 net0200 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkbb net125 VDD pch_mac l=35.0n w=200n m=1
MM42 net125 net0200 net113 VDD pch_mac l=35.0n w=100n m=1
MM0 mq_x clkb net0172 VDD pch_mac l=35.0n w=100n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 net49 qf_x VDD VDD pch_mac l=35.0n w=325.00n m=1
MM70 QN net49 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt SDFKCNARD1BWP35 SI D SE CP CN Q QN VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net26 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net26 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net138 net62 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net54 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net54 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 mq clkb net138 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net62 SE net82 VSS nch_mac l=35.0n w=100n m=1
MM6 net62 net78 net74 VSS nch_mac l=35.0n w=210.0n m=1
MM3 net70 D VSS VSS nch_mac l=35.0n w=210.0n m=1
MM1 net74 CN net70 VSS nch_mac l=35.0n w=210.0n m=1
MM16 net78 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM13 net82 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net110 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net110 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net74 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net62 net78 net158 VDD pch_mac l=35.0n w=115.00n m=1
MM8 qf_x clkbb net146 VDD pch_mac l=35.0n w=175.00n m=1
MM4 net74 CN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM17 net138 net62 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net138 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net146 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net78 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net62 SE net74 VDD pch_mac l=35.0n w=115.00n m=1
MM14 net158 SI VDD VDD pch_mac l=35.0n w=115.00n m=1
.ends
.subckt SDFKCNARD2BWP35 SI D SE CP CN Q QN VDD VSS
MM13 net86 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net90 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM1 net94 CN net98 VSS nch_mac l=35.0n w=210.0n m=1
MM3 net98 D VSS VSS nch_mac l=35.0n w=210.0n m=1
MM6 net42 net90 net94 VSS nch_mac l=35.0n w=210.0n m=1
MM12 net42 SE net86 VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net30 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net121 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net121 VSS nch_mac l=35.0n w=155.00n m=1
MM18 net30 net42 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net45 SI VDD VDD pch_mac l=35.0n w=115.00n m=1
MM5 net42 SE net94 VDD pch_mac l=35.0n w=115.00n m=1
MM15 net90 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net22 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM19 mq clkbb net30 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net30 net42 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net94 CN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM8 qf_x clkbb net22 VDD pch_mac l=35.0n w=175.00n m=1
MM11 net42 net90 net45 VDD pch_mac l=35.0n w=115.00n m=1
MM2 net94 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net58 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net58 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCNARD4BWP35 SI D SE CP CN Q QN VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net129 VSS nch_mac l=35.0n w=100n m=1
MM65 net129 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net241 net229 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net157 VSS nch_mac l=35.0n w=100n m=1
MM9 net157 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net241 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net229 SE net185 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net229 net253 net177 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net173 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net177 CN net173 VSS nch_mac l=35.0n w=145.00n m=1
MM16 net253 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM13 net185 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=1
MM79 mq clkb net213 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=1
MM60 net213 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net177 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net229 net253 net261 VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net249 VDD pch_mac l=35.0n w=120.0n m=1
MM4 net177 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 net241 net229 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net241 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net249 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net253 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net229 SE net177 VDD pch_mac l=35.0n w=185.00n m=1
MM14 net261 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt SDFKCND0BWP35 SI D SE CP CN Q QN VDD VSS
MM13 net185 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net189 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net193 CN net197 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net197 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net205 net189 net193 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net205 SE net185 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net221 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net213 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 qf_x clkb net213 VSS nch_mac l=35.0n w=140.0n m=1
MM18 net221 net205 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net248 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM64 mq clkbb net248 VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net109 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net205 SE net193 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net189 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net140 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM19 mq clkbb net221 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net221 net205 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net193 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net140 VDD pch_mac l=35.0n w=175.00n m=1
MM11 net205 net189 net109 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net193 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net157 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net157 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFKCND1BWP35 SI D SE CP CN Q QN VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net26 VSS nch_mac l=35.0n w=100n m=1
MM65 net26 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net138 net62 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net54 VSS nch_mac l=35.0n w=100n m=1
MM9 net54 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net138 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net62 SE net82 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net62 net78 net74 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net70 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net74 CN net70 VSS nch_mac l=35.0n w=145.00n m=1
MM16 net78 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM13 net82 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net110 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net110 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net74 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net62 net78 net158 VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net146 VDD pch_mac l=35.0n w=275.00n m=1
MM4 net74 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 net138 net62 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net138 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net146 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net78 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net62 SE net74 VDD pch_mac l=35.0n w=185.00n m=1
MM14 net158 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt SDFKCND2BWP35 SI D SE CP CN Q QN VDD VSS
MM13 net86 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net90 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net94 CN net98 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net98 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net42 net90 net94 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net42 SE net86 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net30 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net121 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net121 VSS nch_mac l=35.0n w=100n m=1
MM18 net30 net42 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net45 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net42 SE net94 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net90 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net22 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net30 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net30 net42 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net94 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net22 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net42 net90 net45 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net94 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net58 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net58 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCND4BWP35 SI D SE CP CN Q QN VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net129 VSS nch_mac l=35.0n w=100n m=1
MM65 net129 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net241 net229 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net157 VSS nch_mac l=35.0n w=100n m=1
MM9 net157 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net241 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net229 SE net185 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net229 net253 net177 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net173 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net177 CN net173 VSS nch_mac l=35.0n w=145.00n m=1
MM16 net253 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM13 net185 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM79 mq clkb net213 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM60 net213 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net177 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net229 net253 net261 VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net249 VDD pch_mac l=35.0n w=120.0n m=1
MM4 net177 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 net241 net229 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net241 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net249 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net253 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net229 SE net177 VDD pch_mac l=35.0n w=185.00n m=1
MM14 net261 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt SDFKCNQARD1BWP35 SI D SE CP CN Q VDD VSS
MM13 net81 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net85 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM1 net89 CN net93 VSS nch_mac l=35.0n w=210.0n m=1
MM3 net93 D VSS VSS nch_mac l=35.0n w=210.0n m=1
MM6 net101 net85 net89 VSS nch_mac l=35.0n w=210.0n m=1
MM12 net101 SE net81 VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net117 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=140.0n m=1
MM18 net117 net101 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 SI VDD VDD pch_mac l=35.0n w=115.00n m=1
MM5 net101 SE net89 VDD pch_mac l=35.0n w=115.00n m=1
MM15 net85 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM19 mq clkbb net117 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net117 net101 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net89 CN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM8 qf_x clkbb net40 VDD pch_mac l=35.0n w=175.00n m=1
MM11 net101 net85 net44 VDD pch_mac l=35.0n w=115.00n m=1
MM2 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net53 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net53 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCNQARD2BWP35 SI D SE CP CN Q VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net25 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net25 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net129 net57 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net49 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net49 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 mq clkb net129 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net57 SE net77 VSS nch_mac l=35.0n w=100n m=1
MM6 net57 net141 net69 VSS nch_mac l=35.0n w=210.0n m=1
MM3 net65 D VSS VSS nch_mac l=35.0n w=210.0n m=1
MM1 net69 CN net65 VSS nch_mac l=35.0n w=210.0n m=1
MM16 net141 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM13 net77 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net92 VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net92 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net69 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net57 net141 net120 VDD pch_mac l=35.0n w=115.00n m=1
MM8 qf_x clkbb net137 VDD pch_mac l=35.0n w=175.00n m=1
MM4 net69 CN VDD VDD pch_mac l=35.0n w=115.00n m=1
MM17 net129 net57 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net129 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net137 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net141 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net57 SE net69 VDD pch_mac l=35.0n w=115.00n m=1
MM14 net120 SI VDD VDD pch_mac l=35.0n w=115.00n m=1
.ends
.subckt SDFKCNQARD4BWP35 SI D SE CP CN Q VDD VSS
MM13 net81 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net17 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net89 CN net93 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net41 net17 net89 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net41 SE net81 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net117 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net117 net41 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net41 SE net89 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net17 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net117 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net117 net41 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net89 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net40 VDD pch_mac l=35.0n w=120.0n m=1
MM11 net41 net17 net44 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net72 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq clkb net72 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCNQD0BWP35 SI D SE CP CN Q VDD VSS
MM13 net211 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net153 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net153 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net175 net191 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net177 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net177 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 mq clkb net175 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net191 SE net211 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net191 net275 net203 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net199 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net203 CN net199 VSS nch_mac l=35.0n w=145.00n m=1
MM16 net275 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net221 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net221 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM2 net203 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net191 net275 net283 VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net253 VDD pch_mac l=35.0n w=175.00n m=1
MM4 net203 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 net175 net191 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net175 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net253 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net275 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net191 SE net203 VDD pch_mac l=35.0n w=185.00n m=1
MM14 net283 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt SDFKCNQD1BWP35 SI D SE CP CN Q VDD VSS
MM13 net81 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net85 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net89 CN net93 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net101 net85 net89 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net101 SE net81 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net117 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net117 net101 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net101 SE net89 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net85 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net117 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net117 net101 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net89 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net40 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net101 net85 net44 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net53 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net53 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCNQD2BWP35 SI D SE CP CN Q VDD VSS
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net25 VSS nch_mac l=35.0n w=100n m=1
MM65 net25 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net129 net57 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net49 VSS nch_mac l=35.0n w=100n m=1
MM9 net49 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net129 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net57 SE net77 VSS nch_mac l=35.0n w=145.00n m=1
MM6 net57 net141 net69 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net65 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net69 CN net65 VSS nch_mac l=35.0n w=145.00n m=1
MM16 net141 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM13 net77 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net92 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net92 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net69 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net57 net141 net120 VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net137 VDD pch_mac l=35.0n w=275.00n m=1
MM4 net69 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM17 net129 net57 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net129 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net137 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net141 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net57 SE net69 VDD pch_mac l=35.0n w=185.00n m=1
MM14 net120 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
.ends
.subckt SDFKCNQD4BWP35 SI D SE CP CN Q VDD VSS
MM13 net81 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net17 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net89 CN net93 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net41 net17 net89 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net41 SE net81 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net117 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net117 net41 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net41 SE net89 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net17 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net117 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net117 net41 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net89 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net40 VDD pch_mac l=35.0n w=120.0n m=1
MM11 net41 net17 net44 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net72 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq clkb net72 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCNQUND1BWP35 SI D SE CP CN Q VDD VSS
MM13 net81 SI VSS VSS nch_mac l=35.0n w=145.00n m=1
MM16 net85 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM1 net89 CN net93 VSS nch_mac l=35.0n w=145.00n m=1
MM3 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net101 net85 net89 VSS nch_mac l=35.0n w=145.00n m=1
MM12 net101 SE net81 VSS nch_mac l=35.0n w=145.00n m=1
MM20 mq clkb net117 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 Q VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net117 net101 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net44 SI VDD VDD pch_mac l=35.0n w=185.00n m=1
MM5 net101 SE net89 VDD pch_mac l=35.0n w=185.00n m=1
MM15 net85 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net40 Q VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net117 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net117 net101 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net89 CN VDD VDD pch_mac l=35.0n w=185.00n m=1
MM8 qf_x clkbb net40 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net101 net85 net44 VDD pch_mac l=35.0n w=185.00n m=1
MM2 net89 D VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net53 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net53 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKCSND0BWP35 SI D SE CP CN SN Q QN VDD VSS
MM22 net204 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net183 net204 net184 VSS nch_mac l=35.0n w=120.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net260 net248 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net168 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net168 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 mq clkb net260 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net248 SE net196 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net248 net272 net183 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net184 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net183 D net184 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net272 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net196 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net247 net204 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net204 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net219 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net219 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net183 D net247 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net248 net272 net251 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net255 VDD pch_mac l=35.0n w=175.00n m=1
MM4 net183 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net260 net248 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net260 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net255 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net272 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net248 SE net183 VDD pch_mac l=35.0n w=195.00n m=1
MM14 net251 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCSND1BWP35 SI D SE CP CN SN Q QN VDD VSS
MM13 net95 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net19 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net171 D net107 VSS nch_mac l=35.0n w=245.00n m=1
MM3 net107 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 net43 net19 net171 VSS nch_mac l=35.0n w=215.00n m=1
MM12 net43 SE net95 VSS nch_mac l=35.0n w=120.0n m=1
MM20 mq clkb net31 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net130 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net130 VSS nch_mac l=35.0n w=100n m=1
MM18 net31 net43 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net158 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net158 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net171 net175 net107 VSS nch_mac l=35.0n w=120.0n m=1
MM22 net175 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM14 net11 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net43 SE net171 VDD pch_mac l=35.0n w=195.00n m=1
MM15 net19 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net42 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net31 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net31 net43 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net171 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net42 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net43 net19 net11 VDD pch_mac l=35.0n w=100n m=1
MM2 net171 D net50 VDD pch_mac l=35.0n w=205.00n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net78 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net78 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net175 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net50 net175 VDD VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt SDFKCSND2BWP35 SI D SE CP CN SN Q QN VDD VSS
MM22 net99 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net83 net99 net86 VSS nch_mac l=35.0n w=120.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net35 VSS nch_mac l=35.0n w=100n m=1
MM65 net35 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net155 net143 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net63 VSS nch_mac l=35.0n w=100n m=1
MM9 net63 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net155 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net143 SE net91 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net143 net87 net83 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net86 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net83 D net86 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net87 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net91 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net142 net99 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net99 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net114 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net114 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 net83 D net142 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net143 net87 net146 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net163 VDD pch_mac l=35.0n w=275.00n m=1
MM4 net83 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net155 net143 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net155 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net163 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net87 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net143 SE net83 VDD pch_mac l=35.0n w=195.00n m=1
MM14 net146 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCSND4BWP35 SI D SE CP CN SN Q QN VDD VSS
MM13 net95 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net99 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net171 D net107 VSS nch_mac l=35.0n w=245.00n m=1
MM3 net107 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 net43 net99 net171 VSS nch_mac l=35.0n w=215.00n m=1
MM12 net43 SE net95 VSS nch_mac l=35.0n w=120.0n m=1
MM20 mq clkb net131 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net130 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net130 VSS nch_mac l=35.0n w=100n m=1
MM18 net131 net43 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net151 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net151 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM0 net171 net175 net107 VSS nch_mac l=35.0n w=120.0n m=1
MM22 net175 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM14 net11 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net43 SE net171 VDD pch_mac l=35.0n w=195.00n m=1
MM15 net99 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net23 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net131 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net131 net43 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net171 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net23 VDD pch_mac l=35.0n w=120.0n m=1
MM11 net43 net99 net11 VDD pch_mac l=35.0n w=100n m=1
MM2 net171 D net50 VDD pch_mac l=35.0n w=205.00n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net59 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq clkb net59 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net175 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net50 net175 VDD VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt SDFKCSNQARD1BWP35 SI D SE CP CN SN Q VDD VSS
MM22 net199 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net183 net199 net186 VSS nch_mac l=35.0n w=135.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net139 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net139 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net251 net239 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net163 VSS nch_mac l=35.0n w=100n m=1
MM9 net163 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net251 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net239 SE net191 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net239 net263 net183 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net186 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net183 D net186 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net263 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net191 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net238 net199 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net199 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net227 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net227 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM2 net183 D net238 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net239 net263 net271 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net259 VDD pch_mac l=35.0n w=175.00n m=1
MM4 net183 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net251 net239 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net251 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net259 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net263 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net239 SE net183 VDD pch_mac l=35.0n w=200n m=1
MM14 net271 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCSNQARD2BWP35 SI D SE CP CN SN Q VDD VSS
MM13 net113 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net201 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net121 D net125 VSS nch_mac l=35.0n w=245.00n m=1
MM3 net125 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 net225 net201 net121 VSS nch_mac l=35.0n w=215.00n m=1
MM12 net225 SE net113 VSS nch_mac l=35.0n w=120.0n m=1
MM20 mq clkb net213 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net148 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net148 VSS nch_mac l=35.0n w=100n m=1
MM18 net213 net225 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net165 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM64 mq clkbb net165 VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net121 net265 net125 VSS nch_mac l=35.0n w=135.00n m=1
MM22 net265 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM14 net228 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net225 SE net121 VDD pch_mac l=35.0n w=200n m=1
MM15 net201 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net224 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM19 mq clkbb net213 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net213 net225 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net121 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net224 VDD pch_mac l=35.0n w=175.00n m=1
MM11 net225 net201 net228 VDD pch_mac l=35.0n w=100n m=1
MM2 net121 D net232 VDD pch_mac l=35.0n w=205.00n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net256 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net256 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net265 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net232 net265 VDD VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt SDFKCSNQARD4BWP35 SI D SE CP CN SN Q VDD VSS
MM22 net10 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net14 net10 net74 VSS nch_mac l=35.0n w=120.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net34 VSS nch_mac l=35.0n w=100n m=1
MM65 net34 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net146 net66 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net57 VSS nch_mac l=35.0n w=100n m=1
MM9 net57 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net146 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net66 SE net86 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net66 net158 net14 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net74 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net14 D net74 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net158 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net86 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net133 net10 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net10 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=1
MM79 mq clkb net109 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM60 net109 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net14 D net133 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net66 net158 net166 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net154 VDD pch_mac l=35.0n w=120.0n m=1
MM4 net14 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net146 net66 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net146 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net154 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net158 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net66 SE net14 VDD pch_mac l=35.0n w=195.00n m=1
MM14 net166 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCSNQD0BWP35 SI D SE CP CN SN Q VDD VSS
MM3 net93 CN VSS VSS nch_mac l=35.0n w=270.0n m=1
MM0 net98 net18 net93 VSS nch_mac l=35.0n w=130.0n m=1
MM4 net98 D net93 VSS nch_mac l=35.0n w=270.0n m=1
MM57 net166 Q VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 qf_x clkb net166 VSS nch_mac l=35.0n w=140.0n m=1
MM51 net157 mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM48 mq clkbb net157 VSS nch_mac l=35.0n w=140.0n m=1
MM45 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM44 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM42 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 mq_x clkbb qf_x VSS nch_mac l=35.0n w=140.0n m=1
MM22 net18 SN VSS VSS nch_mac l=35.0n w=270.0n m=1
MM24 net134 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM26 net130 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 mq clkb net122 VSS nch_mac l=35.0n w=255.00n m=1
MM34 net122 net98 net118 VSS nch_mac l=35.0n w=140.0n m=1
MM35 net118 net130 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM36 net114 net134 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net122 SE net114 VSS nch_mac l=35.0n w=140.0n m=1
MM38 mq_x mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 net17 net18 VDD VDD pch_mac l=35.0n w=145.00n m=1
MM23 net18 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net98 D net17 VDD pch_mac l=35.0n w=145.00n m=1
MM6 net98 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM66 net86 Q VDD VDD pch_mac l=35.0n w=175.00n m=1
MM63 qf_x clkbb net86 VDD pch_mac l=35.0n w=175.00n m=1
MM61 net77 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM58 mq clkb net77 VDD pch_mac l=35.0n w=175.00n m=1
MM47 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM46 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM43 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 mq_x clkb qf_x VDD pch_mac l=35.0n w=175.00n m=1
MM25 net134 SI VDD VDD pch_mac l=35.0n w=140.0n m=1
MM28 net45 net134 VDD VDD pch_mac l=35.0n w=140.0n m=1
MM27 net130 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net42 net130 net45 VDD pch_mac l=35.0n w=140.0n m=1
MM31 net41 SE VDD VDD pch_mac l=35.0n w=140.0n m=1
MM30 net42 net98 net41 VDD pch_mac l=35.0n w=140.0n m=1
MM32 mq clkbb net42 VDD pch_mac l=35.0n w=175.00n m=1
MM39 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
.ends
.subckt SDFKCSNQD1BWP35 SI D SE CP CN SN Q VDD VSS
MM22 net199 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net183 net199 net186 VSS nch_mac l=35.0n w=120.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net139 VSS nch_mac l=35.0n w=100n m=1
MM65 net139 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net251 net239 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net163 VSS nch_mac l=35.0n w=100n m=1
MM9 net163 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net251 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net239 SE net191 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net239 net263 net183 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net186 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net183 D net186 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net263 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net191 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net238 net199 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net199 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net227 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net227 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net183 D net238 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net239 net263 net271 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net259 VDD pch_mac l=35.0n w=275.00n m=1
MM4 net183 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net251 net239 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net251 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net259 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net263 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net239 SE net183 VDD pch_mac l=35.0n w=195.00n m=1
MM14 net271 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCSNQD2BWP35 SI D SE CP CN SN Q VDD VSS
MM13 net113 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net201 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net121 D net125 VSS nch_mac l=35.0n w=245.00n m=1
MM3 net125 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 net225 net201 net121 VSS nch_mac l=35.0n w=215.00n m=1
MM12 net225 SE net113 VSS nch_mac l=35.0n w=120.0n m=1
MM20 mq clkb net213 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net148 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net148 VSS nch_mac l=35.0n w=100n m=1
MM18 net213 net225 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net165 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net165 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net121 net265 net125 VSS nch_mac l=35.0n w=120.0n m=1
MM22 net265 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM14 net228 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net225 SE net121 VDD pch_mac l=35.0n w=195.00n m=1
MM15 net201 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net224 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net213 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net213 net225 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 net121 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net224 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net225 net201 net228 VDD pch_mac l=35.0n w=100n m=1
MM2 net121 D net232 VDD pch_mac l=35.0n w=205.00n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net256 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net256 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net265 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net232 net265 VDD VDD pch_mac l=35.0n w=205.00n m=1
.ends
.subckt SDFKCSNQD4BWP35 SI D SE CP CN SN Q VDD VSS
MM22 net10 SN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net14 net10 net74 VSS nch_mac l=35.0n w=120.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net34 VSS nch_mac l=35.0n w=100n m=1
MM65 net34 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net146 net66 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net57 VSS nch_mac l=35.0n w=100n m=1
MM9 net57 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net146 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net66 SE net86 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net66 net158 net14 VSS nch_mac l=35.0n w=215.00n m=1
MM3 net74 CN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 net14 D net74 VSS nch_mac l=35.0n w=245.00n m=1
MM16 net158 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net86 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net133 net10 VDD VDD pch_mac l=35.0n w=205.00n m=1
MM23 net10 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM79 mq clkb net109 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM60 net109 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net14 D net133 VDD pch_mac l=35.0n w=205.00n m=1
MM11 net66 net158 net166 VDD pch_mac l=35.0n w=100n m=1
MM8 qf_x clkbb net154 VDD pch_mac l=35.0n w=120.0n m=1
MM4 net14 CN VDD VDD pch_mac l=35.0n w=100n m=1
MM17 net146 net66 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net146 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net154 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net158 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net66 SE net14 VDD pch_mac l=35.0n w=195.00n m=1
MM14 net166 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKSND0BWP35 SI D SE CP SN Q QN VDD VSS
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=180.0n m=1
MM6 net273 net217 net185 VSS nch_mac l=35.0n w=260.0n m=1
MM18 net205 net273 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM9 net129 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net136 VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 mq clkb net205 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net273 SE net193 VSS nch_mac l=35.0n w=100n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 qf_x clkb net129 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net136 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM22 net241 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net185 net241 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net185 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net217 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net193 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM8 qf_x clkbb net213 VDD pch_mac l=35.0n w=175.00n m=1
MM17 net205 net273 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net205 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net213 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net217 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net273 SE net185 VDD pch_mac l=35.0n w=300n m=1
MM14 net225 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM79 mq clkb net232 VDD pch_mac l=35.0n w=100n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net237 net241 VDD VDD pch_mac l=35.0n w=300n m=1
MM23 net241 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net232 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net185 D net237 VDD pch_mac l=35.0n w=300n m=1
MM11 net273 net217 net225 VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFKSND1BWP35 SI D SE CP SN Q QN VDD VSS
MM22 net10 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net78 net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net34 VSS nch_mac l=35.0n w=100n m=1
MM65 net34 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net146 net70 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net62 VSS nch_mac l=35.0n w=100n m=1
MM9 net62 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net146 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net70 SE net73 VSS nch_mac l=35.0n w=100n m=1
MM6 net70 net158 net78 VSS nch_mac l=35.0n w=260.0n m=1
MM1 net78 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net158 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net73 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM21 net137 net10 VDD VDD pch_mac l=35.0n w=300n m=1
MM23 net10 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net109 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net109 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net78 D net137 VDD pch_mac l=35.0n w=300n m=1
MM11 net70 net158 net141 VDD pch_mac l=35.0n w=120.0n m=1
MM8 qf_x clkbb net145 VDD pch_mac l=35.0n w=275.00n m=1
MM17 net146 net70 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net146 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net145 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net158 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net70 SE net78 VDD pch_mac l=35.0n w=300n m=1
MM14 net141 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFKSND2BWP35 SI D SE CP SN Q QN VDD VSS
MM13 net90 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net94 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net98 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net38 net94 net98 VSS nch_mac l=35.0n w=260.0n m=1
MM12 net38 SE net90 VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net30 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net114 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net114 VSS nch_mac l=35.0n w=100n m=1
MM18 net30 net38 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net98 net166 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net166 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net10 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net38 SE net98 VDD pch_mac l=35.0n w=300n m=1
MM15 net94 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net37 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net30 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net30 net38 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf_x clkbb net37 VDD pch_mac l=35.0n w=275.00n m=1
MM11 net38 net94 net10 VDD pch_mac l=35.0n w=120.0n m=1
MM2 net98 D net86 VDD pch_mac l=35.0n w=300n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net73 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net73 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net166 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net86 net166 VDD VDD pch_mac l=35.0n w=300n m=1
.ends
.subckt SDFKSND4BWP35 SI D SE CP SN Q QN VDD VSS
MM22 net94 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net78 net94 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net34 VSS nch_mac l=35.0n w=100n m=1
MM65 net34 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM69 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net54 net70 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net61 VSS nch_mac l=35.0n w=100n m=1
MM9 net61 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net54 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net70 SE net73 VSS nch_mac l=35.0n w=100n m=1
MM6 net70 net82 net78 VSS nch_mac l=35.0n w=260.0n m=1
MM1 net78 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net82 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net73 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM21 net137 net94 VDD VDD pch_mac l=35.0n w=300n m=1
MM23 net94 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM79 mq clkb net122 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM60 net122 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM70 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 net78 D net137 VDD pch_mac l=35.0n w=300n m=1
MM11 net70 net82 net166 VDD pch_mac l=35.0n w=120.0n m=1
MM8 qf_x clkbb net154 VDD pch_mac l=35.0n w=120.0n m=1
MM17 net54 net70 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net54 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net154 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net82 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net70 SE net78 VDD pch_mac l=35.0n w=300n m=1
MM14 net166 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFKSNQARD1BWP35 SI D SE CP SN Q VDD VSS
MM22 net82 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net98 net82 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net142 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net142 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net30 net38 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net121 VSS nch_mac l=35.0n w=100n m=1
MM9 net121 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net30 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net38 SE net90 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net38 net18 net98 VSS nch_mac l=35.0n w=255.00n m=1
MM1 net98 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net18 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net90 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM14 net41 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net38 SE net98 VDD pch_mac l=35.0n w=295.00n m=1
MM7 net22 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net18 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net45 net82 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net73 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net73 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net82 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM2 net98 D net45 VDD pch_mac l=35.0n w=295.00n m=1
MM8 qf_x clkbb net22 VDD pch_mac l=35.0n w=175.00n m=1
MM17 net30 net38 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM11 net38 net18 net41 VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net30 VDD pch_mac l=35.0n w=215.00n m=1
.ends
.subckt SDFKSNQARD2BWP35 SI D SE CP SN Q VDD VSS
MM22 net9 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net73 net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=155.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net33 VSS nch_mac l=35.0n w=155.00n m=1
MM65 net33 mq_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net49 net65 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net57 VSS nch_mac l=35.0n w=100n m=1
MM9 net57 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net49 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net65 SE net68 VSS nch_mac l=35.0n w=120.0n m=1
MM6 net65 net77 net73 VSS nch_mac l=35.0n w=255.00n m=1
MM1 net73 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net77 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net68 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
MM21 net85 net9 VDD VDD pch_mac l=35.0n w=295.00n m=1
MM23 net9 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net104 VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net104 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net73 D net85 VDD pch_mac l=35.0n w=295.00n m=1
MM11 net65 net77 net157 VDD pch_mac l=35.0n w=120.0n m=1
MM8 qf_x clkbb net136 VDD pch_mac l=35.0n w=175.00n m=1
MM17 net49 net65 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net49 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net136 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM15 net77 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net65 SE net73 VDD pch_mac l=35.0n w=295.00n m=1
MM14 net157 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFKSNQARD4BWP35 SI D SE CP SN Q VDD VSS
MM13 net85 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net89 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net101 net89 net93 VSS nch_mac l=35.0n w=260.0n m=1
MM12 net101 SE net85 VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net29 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net29 net101 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net93 net157 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net157 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net9 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net101 SE net93 VDD pch_mac l=35.0n w=300n m=1
MM15 net89 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net36 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net29 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net29 net101 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf_x clkbb net36 VDD pch_mac l=35.0n w=120.0n m=1
MM11 net101 net89 net9 VDD pch_mac l=35.0n w=120.0n m=1
MM2 net93 D net44 VDD pch_mac l=35.0n w=300n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net68 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq clkb net68 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net157 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net44 net157 VDD VDD pch_mac l=35.0n w=300n m=1
.ends
.subckt SDFKSNQD0BWP35 SI D SE CP SN Q VDD VSS
MM38 mq_x mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net29 SE net21 VSS nch_mac l=35.0n w=140.0n m=1
MM36 net21 net41 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net25 net37 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM34 net29 net81 net25 VSS nch_mac l=35.0n w=140.0n m=1
MM33 mq clkb net29 VSS nch_mac l=35.0n w=255.00n m=1
MM26 net37 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM24 net41 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM22 net45 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 mq_x clkbb qf_x VSS nch_mac l=35.0n w=140.0n m=1
MM42 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM44 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM48 mq clkbb net69 VSS nch_mac l=35.0n w=140.0n m=1
MM51 net69 mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 qf_x clkb net76 VSS nch_mac l=35.0n w=140.0n m=1
MM57 net76 Q VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net81 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net81 net45 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM39 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM32 mq clkbb net101 VDD pch_mac l=35.0n w=175.00n m=1
MM30 net101 net81 net96 VDD pch_mac l=35.0n w=145.00n m=1
MM31 net96 SE VDD VDD pch_mac l=35.0n w=145.00n m=1
MM29 net101 net37 net104 VDD pch_mac l=35.0n w=145.00n m=1
MM27 net37 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM28 net104 net41 VDD VDD pch_mac l=35.0n w=145.00n m=1
MM25 net41 SI VDD VDD pch_mac l=35.0n w=145.00n m=1
XMSLTp1 mq_x clkb qf_x VDD pch_mac l=35.0n w=175.00n m=1
MM43 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM46 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM47 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 mq clkb net137 VDD pch_mac l=35.0n w=175.00n m=1
MM61 net137 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM63 qf_x clkbb net145 VDD pch_mac l=35.0n w=175.00n m=1
MM66 net145 Q VDD VDD pch_mac l=35.0n w=175.00n m=1
MM5 net81 D net157 VDD pch_mac l=35.0n w=340.0n m=1
MM23 net45 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net157 net45 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFKSNQD1BWP35 SI D SE CP SN Q VDD VSS
MM22 net82 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net98 net82 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net142 VSS nch_mac l=35.0n w=100n m=1
MM65 net142 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net30 net38 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net121 VSS nch_mac l=35.0n w=100n m=1
MM9 net121 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net30 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net38 SE net90 VSS nch_mac l=35.0n w=100n m=1
MM6 net38 net18 net98 VSS nch_mac l=35.0n w=260.0n m=1
MM1 net98 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net18 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net90 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM14 net41 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net38 SE net98 VDD pch_mac l=35.0n w=300n m=1
MM7 net22 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net18 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net45 net82 VDD VDD pch_mac l=35.0n w=300n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net73 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq clkb net73 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net82 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM2 net98 D net45 VDD pch_mac l=35.0n w=300n m=1
MM8 qf_x clkbb net22 VDD pch_mac l=35.0n w=275.00n m=1
MM17 net30 net38 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM11 net38 net18 net41 VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net30 VDD pch_mac l=35.0n w=215.00n m=1
.ends
.subckt SDFKSNQD2BWP35 SI D SE CP SN Q VDD VSS
MM22 net9 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net73 net9 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=180.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net33 VSS nch_mac l=35.0n w=100n m=1
MM65 net33 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net49 net65 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkb net57 VSS nch_mac l=35.0n w=100n m=1
MM9 net57 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net49 VSS nch_mac l=35.0n w=155.00n m=1
MM12 net65 SE net68 VSS nch_mac l=35.0n w=100n m=1
MM6 net65 net77 net73 VSS nch_mac l=35.0n w=260.0n m=1
MM1 net73 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net77 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM13 net68 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM21 net85 net9 VDD VDD pch_mac l=35.0n w=300n m=1
MM23 net9 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net104 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net104 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net73 D net85 VDD pch_mac l=35.0n w=300n m=1
MM11 net65 net77 net157 VDD pch_mac l=35.0n w=120.0n m=1
MM8 qf_x clkbb net136 VDD pch_mac l=35.0n w=275.00n m=1
MM17 net49 net65 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM19 mq clkbb net49 VDD pch_mac l=35.0n w=215.00n m=1
MM7 net136 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net77 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net65 SE net73 VDD pch_mac l=35.0n w=300n m=1
MM14 net157 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFKSNQD4BWP35 SI D SE CP SN Q VDD VSS
MM13 net85 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net89 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM1 net93 D VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net101 net89 net93 VSS nch_mac l=35.0n w=260.0n m=1
MM12 net101 SE net85 VSS nch_mac l=35.0n w=100n m=1
MM20 mq clkb net29 VSS nch_mac l=35.0n w=155.00n m=1
MM9 net116 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM10 qf_x clkb net116 VSS nch_mac l=35.0n w=100n m=1
MM18 net29 net101 VSS VSS nch_mac l=35.0n w=155.00n m=1
MM73 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net140 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net140 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net93 net157 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net157 SN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net9 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM5 net101 SE net93 VDD pch_mac l=35.0n w=300n m=1
MM15 net89 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net36 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM19 mq clkbb net29 VDD pch_mac l=35.0n w=215.00n m=1
MM17 net29 net101 VDD VDD pch_mac l=35.0n w=215.00n m=1
MM8 qf_x clkbb net36 VDD pch_mac l=35.0n w=120.0n m=1
MM11 net101 net89 net9 VDD pch_mac l=35.0n w=120.0n m=1
MM2 net93 D net44 VDD pch_mac l=35.0n w=300n m=1
MM74 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net68 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=300n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq clkb net68 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=300n m=2
MM54 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net157 SN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net44 net157 VDD VDD pch_mac l=35.0n w=300n m=1
.ends
.subckt SDFMARD1BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=140.0n m=1
XMSTLn2 net0413 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=250.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=230.0n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=140.0n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=140.0n m=1
XMSTLp1 net0330 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=220.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=220.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFMARD2BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn2 net0413 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=230.0n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=140.0n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=140.0n m=1
XMSLTp1 net0330 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=220.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=220.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFMARD4BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn3 qf_x clkbb net0222 VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn4 net0222 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn2 net0413 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=120.0n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=120.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=140.0n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
XMSLTp3 net0129 mq VDD VDD pch_mac l=35.0n w=245.00n m=1
XMSLTp4 qf_x clkb net0129 VDD pch_mac l=35.0n w=245.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=140.0n m=1
XMSLTp1 net0330 mq VDD VDD pch_mac l=35.0n w=245.00n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=140.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFMD0BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=140.0n m=1
MM11 net0413 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=230.0n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=140.0n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=100n m=1
MM9 net0330 mq VDD VDD pch_mac l=35.0n w=235.00n m=1
XMSLTp1 qf_x clkb net0330 VDD pch_mac l=35.0n w=235.00n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=235.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=235.00n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFMD1BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=280.0n m=1
XMSTLn2 net0413 mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=100n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=100n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=120.0n m=1
XMSTLp1 net0330 mq VDD VDD pch_mac l=35.0n w=310.0n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=310.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=305.00n m=1
.ends
.subckt SDFMD2BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn2 net0413 mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=100n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=100n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 net0330 mq VDD VDD pch_mac l=35.0n w=310.0n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=310.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=305.00n m=1
.ends
.subckt SDFMD4BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMSLTn3 qf_x clkbb net0222 VSS nch_mac l=35.0n w=265.00n m=1
XMSLTn4 net0222 mq VSS VSS nch_mac l=35.0n w=265.00n m=1
XMSLTn1 qf_x clkbb net0413 VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn2 net0413 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
MM16 net0402 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net167 DA net102 VSS nch_mac l=35.0n w=255.00n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=265.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net167 VSS nch_mac l=35.0n w=270.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM64 mq_x clkbb net139 VSS nch_mac l=35.0n w=100n m=1
MM57 net63 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM65 net139 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM15 qf_x clkb net0402 VSS nch_mac l=35.0n w=100n m=1
MM48 net102 SA net182 VSS nch_mac l=35.0n w=255.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM52 net167 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM7 net182 net63 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM0 net175 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net179 DB net182 VSS nch_mac l=35.0n w=185.00n m=1
MM2 net167 net175 net179 VSS nch_mac l=35.0n w=255.00n m=1
XMSLTp3 net0129 mq VDD VDD pch_mac l=35.0n w=285.00n m=1
XMSLTp4 qf_x clkb net0129 VDD pch_mac l=35.0n w=285.00n m=1
MM13 qf_x clkbb net0325 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 net0330 mq VDD VDD pch_mac l=35.0n w=285.00n m=1
XMSLTp2 qf_x clkb net0330 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net15 net175 net86 VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq_x clkb net55 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 net0325 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM44 net79 DA net15 VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM41 net51 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net55 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net63 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM45 mq_x clkbb net79 VDD pch_mac l=35.0n w=210.0n m=1
MM6 net86 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM42 net79 net63 net51 VDD pch_mac l=35.0n w=100n m=1
MM5 net90 DB net86 VDD pch_mac l=35.0n w=230.0n m=1
MM4 net79 SA net90 VDD pch_mac l=35.0n w=175.00n m=1
MM1 net175 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
.ends
.subckt SDFMQARD1BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net18 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net18 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net122 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net30 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net53 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM57 net122 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=230.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=250.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net30 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net37 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn2 net86 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
XMSLTn1 qf_x clkbb net86 VSS nch_mac l=35.0n w=140.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
MM1 net18 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net110 SA net106 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net106 DB net109 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net110 net122 net130 VDD pch_mac l=35.0n w=100n m=1
MM6 net109 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net110 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net122 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net161 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM41 net130 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net110 DA net162 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net177 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net161 VDD pch_mac l=35.0n w=220.0n m=1
MM43 net162 net18 net109 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net170 VDD pch_mac l=35.0n w=220.0n m=1
XMSLTp1 net170 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM13 qf_x clkbb net177 VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt SDFMQARD2BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net98 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net98 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net122 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net81 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net82 VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net42 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
MM57 net122 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net42 VSS nch_mac l=35.0n w=230.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net81 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net82 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn2 net93 mq VSS VSS nch_mac l=35.0n w=230.0n m=1
XMSLTn1 qf_x clkbb net93 VSS nch_mac l=35.0n w=140.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
MM1 net98 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net110 SA net105 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net105 DB net109 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net110 net122 net130 VDD pch_mac l=35.0n w=100n m=1
MM6 net109 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net110 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net122 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net161 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM41 net130 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net110 DA net149 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net177 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net161 VDD pch_mac l=35.0n w=220.0n m=1
MM43 net149 net98 net109 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net170 VDD pch_mac l=35.0n w=220.0n m=1
XMSLTp1 net170 mq VDD VDD pch_mac l=35.0n w=220.0n m=1
MM13 qf_x clkbb net177 VDD pch_mac l=35.0n w=140.0n m=1
.ends
.subckt SDFMQARD4BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net18 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net18 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net46 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net30 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net37 VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net42 mq VSS VSS nch_mac l=35.0n w=120.0n m=1
MM57 net46 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net42 VSS nch_mac l=35.0n w=120.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=255.00n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net30 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net37 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn2 net93 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn1 qf_x clkbb net93 VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn4 net101 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn3 qf_x clkbb net101 VSS nch_mac l=35.0n w=140.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=280.0n m=1
MM1 net18 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net118 SA net114 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net114 DB net117 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net118 net46 net138 VDD pch_mac l=35.0n w=100n m=1
MM6 net117 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net118 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net46 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net134 mq VDD VDD pch_mac l=35.0n w=140.0n m=1
MM41 net138 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net118 DA net157 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net185 qf VDD VDD pch_mac l=35.0n w=140.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net134 VDD pch_mac l=35.0n w=140.0n m=1
MM43 net157 net18 net117 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net178 VDD pch_mac l=35.0n w=245.00n m=1
XMSLTp1 net178 mq VDD VDD pch_mac l=35.0n w=245.00n m=1
MM13 qf_x clkbb net185 VDD pch_mac l=35.0n w=140.0n m=1
XMSLTp4 qf_x clkb net190 VDD pch_mac l=35.0n w=140.0n m=1
XMSLTp3 net190 mq VDD VDD pch_mac l=35.0n w=245.00n m=1
.ends
.subckt SDFMQD0BWP35 DA DB SA SI SE CP Q VDD VSS
MM6 net0291 DB net0298 VSS nch_mac l=35.0n w=220.0n m=1
MM20 net0294 SA VSS VSS nch_mac l=35.0n w=220.0n m=1
MM23 net123 SI VSS VSS nch_mac l=35.0n w=120.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=175.00n m=1
MM7 net0298 net91 VSS VSS nch_mac l=35.0n w=220.0n m=1
MM9 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net0291 DA net0294 VSS nch_mac l=35.0n w=220.0n m=1
MM2 net11 SE net14 VSS nch_mac l=35.0n w=175.00n m=1
MM3 net14 net123 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM0 net91 SA VSS VSS nch_mac l=35.0n w=220.0n m=1
MM48 net27 net111 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 qf_x clkb net75 VSS nch_mac l=35.0n w=140.0n m=1
MM65 net50 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM57 net111 SE VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net50 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq clkb net11 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net11 net0291 net27 VSS nch_mac l=35.0n w=175.00n m=1
MM16 net75 Q VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net0383 net91 VDD VDD pch_mac l=35.0n w=255.00n m=1
MM22 net0291 DA net0383 VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=170.0n m=1
MM18 net0387 SA VDD VDD pch_mac l=35.0n w=255.00n m=1
MM17 net0291 DB net0387 VDD pch_mac l=35.0n w=255.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net91 SA VDD VDD pch_mac l=35.0n w=255.00n m=1
MM4 net95 net111 net99 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net99 net123 VDD VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq clkbb net95 VDD pch_mac l=35.0n w=215.00n m=1
MM58 net111 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net119 mq_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM41 net123 SI VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM44 net95 net0291 net155 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net170 Q VDD VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net119 VDD pch_mac l=35.0n w=170.0n m=1
MM43 net155 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM13 qf_x clkbb net170 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFMQD1BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net18 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net18 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net122 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net30 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net37 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net53 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net122 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net30 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net37 qf VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn2 net86 mq VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb net86 VSS nch_mac l=35.0n w=280.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=305.00n m=1
MM1 net18 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net110 SA net106 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net106 DB net109 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net110 net122 net130 VDD pch_mac l=35.0n w=100n m=1
MM6 net109 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net110 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net122 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net161 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net130 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net110 DA net162 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net177 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net161 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net162 net18 net109 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net170 VDD pch_mac l=35.0n w=310.0n m=1
XMSLTp1 net170 mq VDD VDD pch_mac l=35.0n w=310.0n m=1
MM13 qf_x clkbb net177 VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFMQD2BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net98 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net98 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net122 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net81 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net82 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net42 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net122 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net42 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net81 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net82 qf VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn2 net93 mq VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb net93 VSS nch_mac l=35.0n w=280.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=305.00n m=1
MM1 net98 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net110 SA net105 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net105 DB net109 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net110 net122 net130 VDD pch_mac l=35.0n w=100n m=1
MM6 net109 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net110 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net122 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net161 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net130 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net110 DA net149 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net177 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net161 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net149 net98 net109 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net170 VDD pch_mac l=35.0n w=310.0n m=1
XMSLTp1 net170 mq VDD VDD pch_mac l=35.0n w=310.0n m=1
MM13 qf_x clkbb net177 VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFMQD4BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net18 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net18 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net46 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net30 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net37 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net42 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net46 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net42 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=265.00n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net30 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net37 qf VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn2 net93 mq VSS VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn1 qf_x clkbb net93 VSS nch_mac l=35.0n w=165.00n m=1
XMSLTn4 net101 mq VSS VSS nch_mac l=35.0n w=265.00n m=1
XMSLTn3 qf_x clkbb net101 VSS nch_mac l=35.0n w=265.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=270.0n m=1
MM1 net18 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net118 SA net114 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net114 DB net117 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net118 net46 net138 VDD pch_mac l=35.0n w=100n m=1
MM6 net117 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net118 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net46 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net134 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net138 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net118 DA net157 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net185 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkb net134 VDD pch_mac l=35.0n w=100n m=1
MM43 net157 net18 net117 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net178 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 net178 mq VDD VDD pch_mac l=35.0n w=285.00n m=1
MM13 qf_x clkbb net185 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp4 qf_x clkb net190 VDD pch_mac l=35.0n w=285.00n m=1
XMSLTp3 net190 mq VDD VDD pch_mac l=35.0n w=285.00n m=1
.ends
.subckt SDFMQUND1BWP35 DA DB SA SI SE CP Q VDD VSS
MM2 net26 net18 net14 VSS nch_mac l=35.0n w=255.00n m=1
MM3 net14 DB net17 VSS nch_mac l=35.0n w=185.00n m=1
MM0 net18 SA VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net17 net122 VSS VSS nch_mac l=35.0n w=185.00n m=1
MM52 net26 SE net74 VSS nch_mac l=35.0n w=100n m=1
MM48 net30 SA net17 VSS nch_mac l=35.0n w=255.00n m=1
MM15 qf_x clkb net37 VSS nch_mac l=35.0n w=100n m=1
MM65 net53 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net122 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkbb net53 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=195.00n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=270.0n m=1
MM76 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=195.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net74 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net26 DA net30 VSS nch_mac l=35.0n w=255.00n m=1
MM16 net37 Q VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn2 net86 mq VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb net86 VSS nch_mac l=35.0n w=280.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=305.00n m=1
MM1 net18 SA VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net110 SA net106 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net106 DB net109 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net110 net122 net130 VDD pch_mac l=35.0n w=100n m=1
MM6 net109 SE VDD VDD pch_mac l=35.0n w=230.0n m=1
MM45 mq_x clkbb net110 VDD pch_mac l=35.0n w=210.0n m=1
MM58 net122 SE VDD VDD pch_mac l=35.0n w=280.0n m=1
MM60 net161 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net130 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net110 DA net162 VDD pch_mac l=35.0n w=175.00n m=1
MM14 net177 Q VDD VDD pch_mac l=35.0n w=120.0n m=1
MM79 mq_x clkb net161 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net162 net18 net109 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp2 qf_x clkb net170 VDD pch_mac l=35.0n w=310.0n m=1
XMSLTp1 net170 mq VDD VDD pch_mac l=35.0n w=310.0n m=1
MM13 qf_x clkbb net177 VDD pch_mac l=35.0n w=120.0n m=1
.ends
.subckt SDFNCND0BWP35 SI D SE CPN CDN Q QN VDD VSS
MM19 net222 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM20 net224 net160 net290 VSS nch_mac l=35.0n w=175.00n m=1
MM21 net274 qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 mq mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM24 qf_x CDN net274 VSS nch_mac l=35.0n w=280.0n m=1
MM25 mq_x clkbb net224 VSS nch_mac l=35.0n w=165.00n m=1
MM26 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net250 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM28 mq_x clkb net252 VSS nch_mac l=35.0n w=100n m=1
MM29 net160 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM30 net252 mq net250 VSS nch_mac l=35.0n w=100n m=1
MM31 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM32 QN net240 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net240 clkbb qf VSS nch_mac l=35.0n w=150.0n m=1
MM34 net290 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM35 qf clkb mq VSS nch_mac l=35.0n w=150.0n m=1
MM36 net240 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net224 SE net222 VSS nch_mac l=35.0n w=100n m=1
MM0 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 qf clkbb mq VDD pch_mac l=35.0n w=275.00n m=1
MM2 net290 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM3 mq_x clkbb net168 VDD pch_mac l=35.0n w=120.0n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net240 clkb qf VDD pch_mac l=35.0n w=170.0n m=1
MM6 net148 SE net290 VDD pch_mac l=35.0n w=275.00n m=1
MM7 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net168 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM11 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM12 net146 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net168 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM14 net240 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net160 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM16 QN net240 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM17 mq_x clkb net148 VDD pch_mac l=35.0n w=230.0n m=1
MM18 net148 net160 net146 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFNCND1BWP35 SI D SE CPN CDN Q QN VDD VSS
MM80 net10 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net82 net0237 net17 VSS nch_mac l=35.0n w=175.00n m=1
MM75 net33 CDN VSS VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=230.0n m=1
MM76 qf_x qf net33 VSS nch_mac l=35.0n w=230.0n m=1
MM46 mq_x clkbb net82 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net57 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkb net54 VSS nch_mac l=35.0n w=100n m=1
MM57 net0237 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net54 mq net57 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net66 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM67 net66 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net17 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM73 net66 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net82 SE net10 VSS nch_mac l=35.0n w=100n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net17 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkbb net101 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM68 net66 clkb qf VDD pch_mac l=35.0n w=120.0n m=1
MM44 net158 SE net17 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net101 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=335.00n m=1
MM41 net134 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net101 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net66 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM58 net0237 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net66 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkb net158 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net158 net0237 net134 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFNCND2BWP35 SI D SE CPN CDN Q QN VDD VSS
MM5 net0188 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM4 qf_x qf net0188 VSS nch_mac l=35.0n w=245.00n m=1
MM52 net86 SE net89 VSS nch_mac l=35.0n w=100n m=1
MM73 net102 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net102 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net102 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net125 mq net117 VSS nch_mac l=35.0n w=100n m=1
MM57 net0209 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net125 VSS nch_mac l=35.0n w=100n m=1
MM66 net117 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net86 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net141 VSS nch_mac l=35.0n w=245.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net141 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM47 net86 net0209 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM80 net89 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM0 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM42 net10 net0209 net34 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net10 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net102 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM58 net0209 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM74 net102 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM60 net30 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net34 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM61 net30 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=2
MM44 net10 SE net74 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net102 clkb qf VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkbb net30 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net74 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFNCND4BWP35 SI D SE CPN CDN Q QN VDD VSS
MM0 net0105 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM1 qf_x qf net0105 VSS nch_mac l=35.0n w=245.00n m=1
MM80 net10 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net70 net0237 net17 VSS nch_mac l=35.0n w=175.00n m=1
MM75 net33 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=245.00n m=1
MM76 qf_x qf net33 VSS nch_mac l=35.0n w=245.00n m=1
MM46 mq_x clkbb net70 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net42 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkb net49 VSS nch_mac l=35.0n w=100n m=1
MM57 net0237 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net49 mq net42 VSS nch_mac l=35.0n w=100n m=1
MM67 net58 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net17 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net70 SE net10 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM69 QN net58 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM73 net58 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 qf_x CDN VDD VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net17 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkbb net134 VDD pch_mac l=35.0n w=120.0n m=1
MM68 net58 clkb qf VDD pch_mac l=35.0n w=120.0n m=1
MM44 net146 SE net17 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=295.00n m=2
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net134 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=295.00n m=1
MM41 net149 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net134 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0237 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM45 mq_x clkb net146 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net146 net0237 net149 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 net58 qf_x VDD VDD pch_mac l=35.0n w=300n m=1
MM70 QN net58 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt SDFNCSND0BWP35 SI D SE CPN CDN SDN Q QN VDD VSS
MM28 net272 SDN net248 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net248 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 net252 SDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 mq mq_x net252 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net260 SE net320 VSS nch_mac l=35.0n w=100n m=1
MM23 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM22 net322 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM21 net272 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM20 QN net272 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net284 mq net282 VSS nch_mac l=35.0n w=100n m=1
MM17 net180 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 mq_x clkb net284 VSS nch_mac l=35.0n w=100n m=1
MM15 net282 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM14 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 mq_x clkbb net260 VSS nch_mac l=35.0n w=165.00n m=1
MM12 qf_x qf net316 VSS nch_mac l=35.0n w=280.0n m=1
MM11 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM10 net316 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net320 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM8 net260 net180 net322 VSS nch_mac l=35.0n w=175.00n m=1
MM81 net272 SDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM80 net272 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM74 net168 net180 net188 VDD pch_mac l=35.0n w=100n m=1
MM73 mq_x clkb net168 VDD pch_mac l=35.0n w=230.0n m=1
MM63 QN net272 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM62 net180 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM59 net184 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 net188 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM49 mq SDN VDD VDD pch_mac l=35.0n w=210.0n m=1
MM40 net184 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM29 mq mq_x VDD VDD pch_mac l=35.0n w=300n m=1
MM39 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM38 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 qf_x CDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net168 SE net322 VDD pch_mac l=35.0n w=275.00n m=1
MM35 net272 clkb qf VDD pch_mac l=35.0n w=210.0n m=1
MM34 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM33 mq_x clkbb net184 VDD pch_mac l=35.0n w=120.0n m=1
MM32 net322 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM31 qf clkbb mq VDD pch_mac l=35.0n w=210.0n m=1
MM30 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFNCSND1BWP35 SI D SE CPN CDN SDN Q QN VDD VSS
MM6 net0221 SDN net99 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net99 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM3 net110 SDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM2 mq mq_x net110 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net111 SE net114 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net79 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0221 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net0221 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net135 mq net138 VSS nch_mac l=35.0n w=100n m=1
MM57 net0236 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net135 VSS nch_mac l=35.0n w=100n m=1
MM66 net138 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net111 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net167 VSS nch_mac l=35.0n w=230.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net167 CDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM51 net114 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net111 net0236 net79 VSS nch_mac l=35.0n w=175.00n m=1
MM5 net0221 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0221 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net19 net0236 net22 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net19 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net0221 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0236 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net78 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net22 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM61 net78 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM44 net19 SE net79 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0221 clkb qf VDD pch_mac l=35.0n w=160.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkbb net78 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net79 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFNCSND2BWP35 SI D SE CPN CDN SDN Q QN VDD VSS
MM47 net75 net0253 net67 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net78 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net30 CDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf net30 VSS nch_mac l=35.0n w=230.0n m=1
MM46 mq_x clkbb net75 VSS nch_mac l=35.0n w=165.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net54 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkb net51 VSS nch_mac l=35.0n w=100n m=1
MM57 net0253 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net51 mq net54 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net0161 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net0161 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM48 net67 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM52 net75 SE net78 VSS nch_mac l=35.0n w=100n m=1
MM2 mq mq_x net83 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net83 SDN VSS VSS nch_mac l=35.0n w=225.00n m=1
MM7 net94 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM6 net0161 SDN net94 VSS nch_mac l=35.0n w=155.00n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM43 net67 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkbb net151 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net0161 clkb qf VDD pch_mac l=35.0n w=160.0n m=1
MM44 net167 SE net67 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net151 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net170 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net151 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM58 net0253 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net0161 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 mq_x clkb net167 VDD pch_mac l=35.0n w=230.0n m=1
MM42 net167 net0253 net170 VDD pch_mac l=35.0n w=100n m=1
MM4 net0161 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net0161 SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFNCSND4BWP35 SI D SE CPN CDN SDN Q QN VDD VSS
MM9 net0203 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM8 qf_x qf net0203 VSS nch_mac l=35.0n w=245.00n m=1
MM6 net0221 SDN net99 VSS nch_mac l=35.0n w=155.00n m=1
MM7 net99 qf_x VSS VSS nch_mac l=35.0n w=155.00n m=1
MM3 net103 SDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM2 mq mq_x net103 VSS nch_mac l=35.0n w=280.0n m=1
MM52 net111 SE net114 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=155.00n m=1
MM48 net66 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0221 clkbb qf VSS nch_mac l=35.0n w=155.00n m=1
MM69 QN net0221 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net135 mq net147 VSS nch_mac l=35.0n w=100n m=1
MM57 net0236 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net135 VSS nch_mac l=35.0n w=100n m=1
MM66 net147 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net111 VSS nch_mac l=35.0n w=165.00n m=1
MM76 qf_x qf net167 VSS nch_mac l=35.0n w=245.00n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net167 CDN VSS VSS nch_mac l=35.0n w=245.00n m=1
MM51 net114 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net111 net0236 net66 VSS nch_mac l=35.0n w=175.00n m=1
MM10 qf_x CDN VDD VDD pch_mac l=35.0n w=100n m=1
MM5 net0221 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0221 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net19 net0236 net22 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net19 VDD pch_mac l=35.0n w=230.0n m=1
MM70 QN net0221 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net0236 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net78 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net22 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM61 net78 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x qf VDD VDD pch_mac l=35.0n w=315.00n m=2
MM77 qf_x CDN VDD VDD pch_mac l=35.0n w=315.00n m=1
MM44 net19 SE net66 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0221 clkb qf VDD pch_mac l=35.0n w=160.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net78 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net66 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=295.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq mq_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFND0BWP35 SI D SE CPN Q QN VDD VSS
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net341 net397 net279 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net339 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkbb net341 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM66 net305 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net397 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 mq_x clkb net305 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM69 QN net325 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM67 net325 clkbb qf VSS nch_mac l=35.0n w=140.0n m=1
MM48 net279 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=265.00n m=1
MM73 net325 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 net341 SE net339 VSS nch_mac l=35.0n w=100n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM0 mq_x clkbb net347 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=285.00n m=1
MM43 net279 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 net347 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM68 net325 clkb qf VDD pch_mac l=35.0n w=285.00n m=1
MM44 net409 SE net279 VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM41 net389 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM74 net325 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 net397 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net325 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM45 mq_x clkb net409 VDD pch_mac l=35.0n w=200n m=1
MM42 net409 net397 net389 VDD pch_mac l=35.0n w=100n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFND1BWP35 SI D SE CPN Q QN VDD VSS
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net81 SE net137 VSS nch_mac l=35.0n w=100n m=1
MM73 net97 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net61 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net97 clkbb qf VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN net97 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 mq_x clkb net112 VSS nch_mac l=35.0n w=100n m=1
MM57 net0197 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM66 net112 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net81 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net137 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net81 net0197 net61 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net13 net0197 net16 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net13 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net97 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0197 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM74 net97 qf_x VDD VDD pch_mac l=35.0n w=330.0n m=1
MM41 net16 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net13 SE net61 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net97 clkb qf VDD pch_mac l=35.0n w=285.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 net0160 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM43 net61 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=285.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 mq_x clkbb net0160 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFND2BWP35 SI D SE CPN Q QN VDD VSS
MM47 net69 net0208 net108 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net72 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM46 mq_x clkbb net69 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net44 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net0208 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 mq_x clkb net44 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net53 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net53 clkbb qf VSS nch_mac l=35.0n w=265.00n m=1
MM48 net108 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=265.00n m=1
MM73 net53 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM52 net69 SE net72 VSS nch_mac l=35.0n w=100n m=1
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 mq_x clkbb net0163 VDD pch_mac l=35.0n w=100n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=285.00n m=1
MM43 net108 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 net0163 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net53 clkb qf VDD pch_mac l=35.0n w=285.00n m=1
MM44 net137 SE net108 VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM41 net140 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM74 net53 qf_x VDD VDD pch_mac l=35.0n w=335.00n m=1
MM58 net0208 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net53 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 mq_x clkb net137 VDD pch_mac l=35.0n w=200n m=1
MM42 net137 net0208 net140 VDD pch_mac l=35.0n w=100n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFND4BWP35 SI D SE CPN Q QN VDD VSS
MM2 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM52 net81 SE net137 VSS nch_mac l=35.0n w=100n m=1
MM73 net97 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net61 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net97 clkbb qf VSS nch_mac l=35.0n w=265.00n m=1
MM69 QN net97 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 mq_x clkb net117 VSS nch_mac l=35.0n w=100n m=1
MM57 net0196 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM66 net117 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net81 VSS nch_mac l=35.0n w=175.00n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net137 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net81 net0196 net61 VSS nch_mac l=35.0n w=175.00n m=1
MM1 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM42 net13 net0196 net16 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net13 VDD pch_mac l=35.0n w=200n m=1
MM70 QN net97 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net0196 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM74 net97 qf_x VDD VDD pch_mac l=35.0n w=325.00n m=1
MM41 net16 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net13 SE net61 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net97 clkb qf VDD pch_mac l=35.0n w=285.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 net0158 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM43 net61 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=285.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 mq_x clkbb net0158 VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFNSND0BWP35 SI D SE CPN SDN Q QN VDD VSS
MM27 net266 SDN net290 VSS nch_mac l=35.0n w=280.0n m=1
MM28 net290 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 net280 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM30 mq SDN net280 VSS nch_mac l=35.0n w=220.0n m=1
MM31 net278 SE net226 VSS nch_mac l=35.0n w=100n m=1
MM32 qf clkb mq VSS nch_mac l=35.0n w=220.0n m=1
MM33 net220 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM34 net266 clkbb qf VSS nch_mac l=35.0n w=220.0n m=1
MM35 QN net266 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM36 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net244 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM38 net198 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM39 mq_x clkb net244 VSS nch_mac l=35.0n w=100n m=1
MM40 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x clkbb net278 VSS nch_mac l=35.0n w=175.00n m=1
MM50 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM59 clkb CPN VSS VSS nch_mac l=35.0n w=140.0n m=1
MM61 net226 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM62 net278 net198 net220 VSS nch_mac l=35.0n w=175.00n m=1
MM8 net266 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM9 net266 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net210 net198 net190 VDD pch_mac l=35.0n w=100n m=1
MM11 mq_x clkb net210 VDD pch_mac l=35.0n w=220.0n m=1
MM12 QN net266 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM13 net198 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM14 net164 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM15 net190 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM16 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM17 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net210 SE net220 VDD pch_mac l=35.0n w=275.00n m=1
MM19 net266 clkb qf VDD pch_mac l=35.0n w=100n m=1
MM20 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 mq_x clkbb net164 VDD pch_mac l=35.0n w=100n m=1
MM22 net220 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM23 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM24 clkb CPN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM26 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFNSND1BWP35 SI D SE CPN SDN Q QN VDD VSS
MM6 net0203 SDN net90 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net90 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net101 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM2 mq SDN net101 VSS nch_mac l=35.0n w=220.0n m=1
MM52 net102 SE net154 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=220.0n m=1
MM48 net53 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0203 clkbb qf VSS nch_mac l=35.0n w=220.0n m=1
MM69 QN net0203 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net126 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net0218 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net126 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net102 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net102 net0218 net53 VSS nch_mac l=35.0n w=175.00n m=1
MM5 net0203 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0203 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net18 net0218 net21 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net18 VDD pch_mac l=35.0n w=220.0n m=1
MM70 QN net0203 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM58 net0218 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net34 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net21 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net18 SE net53 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0203 clkb qf VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkbb net34 VDD pch_mac l=35.0n w=100n m=1
MM43 net53 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFNSND2BWP35 SI D SE CPN SDN Q QN VDD VSS
MM47 net165 net237 net0227 VSS nch_mac l=35.0n w=175.00n m=1
MM51 net113 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net165 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkb net136 VSS nch_mac l=35.0n w=100n m=1
MM57 net237 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM65 net136 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM69 QN net153 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net153 clkbb qf VSS nch_mac l=35.0n w=220.0n m=1
MM48 net0227 D VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=220.0n m=1
MM52 net165 SE net113 VSS nch_mac l=35.0n w=100n m=1
MM2 mq SDN net173 VSS nch_mac l=35.0n w=220.0n m=1
MM3 net173 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM7 net184 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net153 SDN net184 VSS nch_mac l=35.0n w=280.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM43 net0227 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkbb net208 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net153 clkb qf VDD pch_mac l=35.0n w=100n m=1
MM44 net249 SE net0227 VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM41 net252 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net208 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM58 net237 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM70 QN net153 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM45 mq_x clkb net249 VDD pch_mac l=35.0n w=220.0n m=1
MM42 net249 net237 net252 VDD pch_mac l=35.0n w=100n m=1
MM4 net153 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net153 SDN VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFNSND4BWP35 SI D SE CPN SDN Q QN VDD VSS
MM6 net0204 SDN net90 VSS nch_mac l=35.0n w=280.0n m=1
MM7 net90 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net101 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM2 mq SDN net101 VSS nch_mac l=35.0n w=220.0n m=1
MM52 net102 SE net105 VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkb mq VSS nch_mac l=35.0n w=220.0n m=1
MM48 net66 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM67 net0204 clkbb qf VSS nch_mac l=35.0n w=220.0n m=1
MM69 QN net0204 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM65 net137 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM57 net0218 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM64 mq_x clkb net137 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkbb net102 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM53 clkb CPN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net105 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net102 net0218 net66 VSS nch_mac l=35.0n w=175.00n m=1
MM5 net0204 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 net0204 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net18 net0218 net38 VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkb net18 VDD pch_mac l=35.0n w=220.0n m=1
MM70 QN net0204 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM58 net0218 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net65 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM41 net38 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM0 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net18 SE net66 VDD pch_mac l=35.0n w=275.00n m=1
MM68 net0204 clkb qf VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM79 mq_x clkbb net65 VDD pch_mac l=35.0n w=100n m=1
MM43 net66 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkbb mq VDD pch_mac l=35.0n w=310.0n m=1
MM54 clkb CPN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt SDFQD0BWP35 SI D SE CP Q VDD VSS
MM32 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM34 net246 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 mq_x clkbb net246 VSS nch_mac l=35.0n w=140.0n m=1
MM36 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 mq_x clkb net200 VSS nch_mac l=35.0n w=200n m=1
MM38 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM39 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 net224 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM42 net192 SE VSS VSS nch_mac l=35.0n w=175.00n m=1
MM43 net200 net192 net224 VSS nch_mac l=35.0n w=175.00n m=1
MM51 qf clkb net208 VSS nch_mac l=35.0n w=140.0n m=1
MM52 net208 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM54 net198 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM57 net200 SE net198 VSS nch_mac l=35.0n w=140.0n m=1
MM11 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM12 net192 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM15 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 mq_x clkbb net140 VDD pch_mac l=35.0n w=170.0n m=1
MM17 net158 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 mq mq_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM19 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM20 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net140 SE net224 VDD pch_mac l=35.0n w=275.00n m=1
MM22 mq_x clkb net158 VDD pch_mac l=35.0n w=170.0n m=1
MM23 qf clkb mq VDD pch_mac l=35.0n w=170.0n m=1
MM24 net224 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net142 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM29 qf clkbb net142 VDD pch_mac l=35.0n w=170.0n m=1
MM30 net140 net192 net136 VDD pch_mac l=35.0n w=170.0n m=1
MM31 net136 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFQD1BWP35 SI D SE CP Q VDD VSS
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM65 net35 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net35 VSS nch_mac l=35.0n w=140.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=240.0n m=1
MM46 mq_x clkb net16 VSS nch_mac l=35.0n w=200n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net0170 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net8 SE VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net16 net8 net0170 VSS nch_mac l=35.0n w=175.00n m=1
MM9 qf clkb net68 VSS nch_mac l=35.0n w=140.0n m=1
MM10 net68 qf_x VSS VSS nch_mac l=35.0n w=240.0n m=1
MM3 net12 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net16 SE net12 VSS nch_mac l=35.0n w=100n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net8 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net128 VDD pch_mac l=35.0n w=170.0n m=1
MM60 net111 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net128 SE net0170 VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net111 VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0170 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM5 net127 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 qf clkbb net127 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net128 net8 net132 VDD pch_mac l=35.0n w=100n m=1
MM6 net132 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQD2BWP35 SI D SE CP Q VDD VSS
MM10 net79 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 qf clkb net79 VSS nch_mac l=35.0n w=265.00n m=1
MM27 net124 net68 net0202 VSS nch_mac l=35.0n w=175.00n m=1
MM47 net0202 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net124 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net111 VSS nch_mac l=35.0n w=100n m=1
MM65 net111 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net124 SE net128 VSS nch_mac l=35.0n w=100n m=1
MM3 net128 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM14 net68 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM6 net8 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net12 net68 net8 VDD pch_mac l=35.0n w=100n m=1
MM4 qf clkbb net20 VDD pch_mac l=35.0n w=285.00n m=1
MM5 net20 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net0202 D VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq_x clkb net35 VDD pch_mac l=35.0n w=100n m=1
MM44 net12 SE net0202 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM60 net35 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net12 VDD pch_mac l=35.0n w=200n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 net68 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt SDFQD4BWP35 SI D SE CP Q VDD VSS
MM14 net8 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM3 net19 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net16 SE net19 VSS nch_mac l=35.0n w=100n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM65 net35 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net35 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net16 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net63 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net16 net8 net63 VSS nch_mac l=35.0n w=175.00n m=1
MM9 qf clkb net68 VSS nch_mac l=35.0n w=265.00n m=1
MM10 net68 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 net8 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net128 VDD pch_mac l=35.0n w=200n m=1
MM60 net111 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net128 SE net63 VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net111 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM26 net63 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM5 net127 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 qf clkbb net127 VDD pch_mac l=35.0n w=285.00n m=1
MM7 net128 net8 net132 VDD pch_mac l=35.0n w=100n m=1
MM6 net132 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQND0BWP35 SI D SE CP QN VDD VSS
MM36 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net237 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM38 qf clkb net237 VSS nch_mac l=35.0n w=140.0n m=1
MM39 mq mq_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 qf_x qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 mq_x clkbb net223 VSS nch_mac l=35.0n w=140.0n m=1
MM42 net223 mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM43 qf clkbb mq VSS nch_mac l=35.0n w=140.0n m=1
MM44 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM45 mq_x clkb net187 VSS nch_mac l=35.0n w=200n m=1
MM46 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net193 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM48 net199 SE VSS VSS nch_mac l=35.0n w=175.00n m=1
MM51 net187 net199 net193 VSS nch_mac l=35.0n w=175.00n m=1
MM52 net191 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 net187 SE net191 VSS nch_mac l=35.0n w=140.0n m=1
MM2 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 qf clkbb net175 VDD pch_mac l=35.0n w=100n m=1
MM6 net175 qf_x VDD VDD pch_mac l=35.0n w=100n m=1
MM7 qf clkb mq VDD pch_mac l=35.0n w=170.0n m=1
MM8 mq_x clkb net155 VDD pch_mac l=35.0n w=170.0n m=1
MM13 qf_x qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM14 mq mq_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 net155 mq VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net199 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM27 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM30 mq_x clkbb net127 VDD pch_mac l=35.0n w=170.0n m=1
MM31 clkbb clkb VDD VDD pch_mac l=35.0n w=300n m=1
MM32 net127 SE net193 VDD pch_mac l=35.0n w=275.00n m=1
MM33 net193 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM34 net127 net199 net123 VDD pch_mac l=35.0n w=170.0n m=1
MM35 net123 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFQND1BWP35 SI D SE CP QN VDD VSS
MM3 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net76 qf_x VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf clkb net76 VSS nch_mac l=35.0n w=100n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq_x clkbb net96 VSS nch_mac l=35.0n w=100n m=1
MM65 net96 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net132 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net0232 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 net120 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net132 net120 net0232 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net128 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM18 net132 SE net128 VSS nch_mac l=35.0n w=100n m=1
MM2 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 qf clkbb net16 VDD pch_mac l=35.0n w=285.00n m=1
MM5 net16 qf_x VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq_x clkb net27 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=270.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM60 net27 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM19 net120 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net64 VDD pch_mac l=35.0n w=200n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net64 SE net0232 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net0232 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net64 net120 net68 VDD pch_mac l=35.0n w=100n m=1
MM29 net68 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQND2BWP35 SI D SE CP QN VDD VSS
MM3 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM10 net76 qf_x VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf clkb net76 VSS nch_mac l=35.0n w=100n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net96 VSS nch_mac l=35.0n w=100n m=1
MM65 net96 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net132 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net0232 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 net120 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net132 net120 net0232 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net128 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM18 net132 SE net128 VSS nch_mac l=35.0n w=100n m=1
MM2 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 qf clkbb net16 VDD pch_mac l=35.0n w=285.00n m=1
MM5 net16 qf_x VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq_x clkb net27 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM60 net27 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM19 net120 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net64 VDD pch_mac l=35.0n w=200n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net64 SE net0232 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net0232 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net64 net120 net68 VDD pch_mac l=35.0n w=100n m=1
MM29 net68 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQND4BWP35 SI D SE CP QN VDD VSS
MM3 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM10 net76 qf_x VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf clkb net76 VSS nch_mac l=35.0n w=100n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net96 VSS nch_mac l=35.0n w=100n m=1
MM65 net96 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net132 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net0243 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 net120 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net132 net120 net0243 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net128 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM18 net132 SE net128 VSS nch_mac l=35.0n w=100n m=1
MM2 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM4 qf clkbb net16 VDD pch_mac l=35.0n w=285.00n m=1
MM5 net16 qf_x VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq_x clkb net27 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM60 net27 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM19 net120 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net64 VDD pch_mac l=35.0n w=200n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net64 SE net0243 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net0243 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net64 net120 net68 VDD pch_mac l=35.0n w=100n m=1
MM29 net68 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQNUND1BWP35 SI D SE CP QN VDD VSS
MM10 net76 QN VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf clkb net76 VSS nch_mac l=35.0n w=100n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM76 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net96 VSS nch_mac l=35.0n w=100n m=1
MM65 net96 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net132 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net127 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM15 net120 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM16 net132 net120 net127 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net128 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM18 net132 SE net128 VSS nch_mac l=35.0n w=100n m=1
MM4 qf clkbb net16 VDD pch_mac l=35.0n w=285.00n m=1
MM5 net16 QN VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq_x clkb net27 VDD pch_mac l=35.0n w=100n m=1
MM77 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM60 net27 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM19 net120 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net64 VDD pch_mac l=35.0n w=200n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net64 SE net127 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net127 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net64 net120 net68 VDD pch_mac l=35.0n w=100n m=1
MM29 net68 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFQXD1BWP35 SI D SE CP Q VDD VSS
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM65 net35 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net35 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net16 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=270.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net0170 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net8 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM27 net16 net8 net0170 VSS nch_mac l=35.0n w=175.00n m=1
MM9 qf clkb net68 VSS nch_mac l=35.0n w=265.00n m=1
MM10 net68 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net12 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net16 SE net12 VSS nch_mac l=35.0n w=100n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 net8 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net128 VDD pch_mac l=35.0n w=200n m=1
MM60 net111 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=285.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net128 SE net0170 VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net111 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=285.00n m=1
MM26 net0170 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM5 net127 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 qf clkbb net127 VDD pch_mac l=35.0n w=285.00n m=1
MM7 net128 net8 net132 VDD pch_mac l=35.0n w=100n m=1
MM6 net132 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFSND0BWP35 SI D SE CP SDN Q QN VDD VSS
MM49 net293 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM50 net293 SDN net277 VSS nch_mac l=35.0n w=280.0n m=1
MM51 mq SDN net281 VSS nch_mac l=35.0n w=220.0n m=1
MM52 net281 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM53 net277 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM54 QN net293 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM55 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM56 net227 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM57 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM58 mq_x clkbb net253 VSS nch_mac l=35.0n w=100n m=1
MM59 net253 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM61 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM62 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM63 mq_x clkb net237 VSS nch_mac l=35.0n w=175.00n m=1
MM66 net237 SE net225 VSS nch_mac l=35.0n w=100n m=1
MM67 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM68 net237 net165 net227 VSS nch_mac l=35.0n w=175.00n m=1
MM69 net225 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM70 net165 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM26 QN net293 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM27 net293 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM31 net293 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM33 net293 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM34 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM35 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM36 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM37 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM38 mq_x clkb net177 VDD pch_mac l=35.0n w=100n m=1
MM39 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM40 net177 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM41 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM42 mq_x clkbb net149 VDD pch_mac l=35.0n w=220.0n m=1
MM43 net165 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM44 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM45 net149 SE net227 VDD pch_mac l=35.0n w=275.00n m=1
MM46 net227 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM47 net149 net165 net145 VDD pch_mac l=35.0n w=100n m=1
MM48 net145 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFSND1BWP35 SI D SE CP SDN Q QN VDD VSS
MM32 net86 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM7 net86 SDN net93 VSS nch_mac l=35.0n w=280.0n m=1
MM25 mq SDN net98 VSS nch_mac l=35.0n w=220.0n m=1
MM14 net98 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM9 net93 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 QN net86 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net126 VSS nch_mac l=35.0n w=100n m=1
MM65 net126 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net142 VSS nch_mac l=35.0n w=175.00n m=1
MM18 net142 SE net145 VSS nch_mac l=35.0n w=100n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net142 net62 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net145 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM15 net62 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM2 QN net86 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net86 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 net86 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM8 net86 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM79 mq_x clkb net45 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net45 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net78 VDD pch_mac l=35.0n w=220.0n m=1
MM19 net62 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net78 SE net74 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net74 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net78 net62 net82 VDD pch_mac l=35.0n w=100n m=1
MM29 net82 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFSND2BWP35 SI D SE CP SDN Q QN VDD VSS
MM32 net86 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM7 net86 SDN net93 VSS nch_mac l=35.0n w=280.0n m=1
MM25 mq SDN net98 VSS nch_mac l=35.0n w=220.0n m=1
MM14 net98 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM9 net93 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 QN net86 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM12 net74 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net126 VSS nch_mac l=35.0n w=100n m=1
MM65 net126 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net142 VSS nch_mac l=35.0n w=175.00n m=1
MM18 net142 SE net145 VSS nch_mac l=35.0n w=100n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net142 net62 net74 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net145 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM15 net62 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM2 QN net86 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net86 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 net86 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM8 net86 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM79 mq_x clkb net45 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net45 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net78 VDD pch_mac l=35.0n w=220.0n m=1
MM19 net62 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net78 SE net74 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net74 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net78 net62 net82 VDD pch_mac l=35.0n w=100n m=1
MM29 net82 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFSND4BWP35 SI D SE CP SDN Q QN VDD VSS
MM32 net103 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM7 net103 SDN net110 VSS nch_mac l=35.0n w=280.0n m=1
MM25 mq SDN net115 VSS nch_mac l=35.0n w=220.0n m=1
MM14 net115 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM9 net110 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 QN net103 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM12 net170 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM64 mq_x clkbb net143 VSS nch_mac l=35.0n w=100n m=1
MM65 net143 mq VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 mq_x clkb net159 VSS nch_mac l=35.0n w=175.00n m=1
MM18 net159 SE net171 VSS nch_mac l=35.0n w=100n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net159 net231 net170 VSS nch_mac l=35.0n w=175.00n m=1
MM17 net171 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM15 net231 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM2 QN net103 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net103 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM30 net103 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM8 net103 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM79 mq_x clkb net219 VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net219 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 mq_x clkbb net247 VDD pch_mac l=35.0n w=220.0n m=1
MM19 net231 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net247 SE net170 VDD pch_mac l=35.0n w=275.00n m=1
MM24 net170 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM28 net247 net231 net251 VDD pch_mac l=35.0n w=100n m=1
MM29 net251 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SDFSNQD0BWP35 SI D SE CP SDN Q VDD VSS
MM45 net158 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM44 net214 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM43 net226 net158 net254 VSS nch_mac l=35.0n w=175.00n m=1
MM42 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 net226 SE net214 VSS nch_mac l=35.0n w=100n m=1
MM40 mq_x clkb net226 VSS nch_mac l=35.0n w=175.00n m=1
MM39 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM38 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM37 net244 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM36 mq_x clkbb net244 VSS nch_mac l=35.0n w=100n m=1
MM35 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM34 net254 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM33 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net272 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net268 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM26 mq SDN net268 VSS nch_mac l=35.0n w=220.0n m=1
MM3 net278 SDN net272 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net278 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM66 net138 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM63 net142 net158 net138 VDD pch_mac l=35.0n w=100n m=1
MM62 net254 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM61 net142 SE net254 VDD pch_mac l=35.0n w=275.00n m=1
MM59 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 net158 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM57 mq_x clkbb net142 VDD pch_mac l=35.0n w=220.0n m=1
MM56 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM55 net170 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM54 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM53 mq_x clkb net170 VDD pch_mac l=35.0n w=100n m=1
MM52 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM51 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM50 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM49 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM48 net278 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM47 net278 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM46 net278 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SDFSNQD1BWP35 SI D SE CP SDN Q VDD VSS
MM15 net9 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM17 net13 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net25 net9 net20 VSS nch_mac l=35.0n w=175.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net25 SE net13 VSS nch_mac l=35.0n w=100n m=1
MM1 mq_x clkb net25 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM65 net41 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net41 VSS nch_mac l=35.0n w=100n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net20 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM9 net76 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net72 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM25 mq SDN net72 VSS nch_mac l=35.0n w=220.0n m=1
MM7 net77 SDN net76 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net77 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM29 net88 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM28 net85 net9 net88 VDD pch_mac l=35.0n w=100n m=1
MM24 net20 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM23 net85 SE net20 VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net9 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM21 mq_x clkbb net85 VDD pch_mac l=35.0n w=220.0n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net124 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net124 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM8 net77 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM30 net77 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM6 net77 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFSNQD2BWP35 SI D SE CP SDN Q VDD VSS
MM15 net9 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM17 net28 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net25 net9 net20 VSS nch_mac l=35.0n w=175.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net25 SE net28 VSS nch_mac l=35.0n w=100n m=1
MM1 mq_x clkb net25 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM65 net48 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net48 VSS nch_mac l=35.0n w=100n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net20 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net76 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net72 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM25 mq SDN net72 VSS nch_mac l=35.0n w=220.0n m=1
MM7 net77 SDN net76 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net77 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM29 net88 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM28 net85 net9 net88 VDD pch_mac l=35.0n w=100n m=1
MM24 net20 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM23 net85 SE net20 VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net9 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM21 mq_x clkbb net85 VDD pch_mac l=35.0n w=220.0n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net113 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net113 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM8 net77 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM30 net77 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM6 net77 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SDFSNQD4BWP35 SI D SE CP SDN Q VDD VSS
MM15 net9 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM17 net13 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM16 net25 net9 net20 VSS nch_mac l=35.0n w=175.00n m=1
MM0 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net25 SE net13 VSS nch_mac l=35.0n w=100n m=1
MM1 mq_x clkb net25 VSS nch_mac l=35.0n w=175.00n m=1
MM11 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=220.0n m=1
MM65 net41 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net41 VSS nch_mac l=35.0n w=100n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM12 net20 D VSS VSS nch_mac l=35.0n w=175.00n m=1
MM5 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM9 net61 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net65 mq_x VSS VSS nch_mac l=35.0n w=220.0n m=1
MM25 mq SDN net65 VSS nch_mac l=35.0n w=220.0n m=1
MM7 net77 SDN net61 VSS nch_mac l=35.0n w=280.0n m=1
MM32 net77 clkb qf VSS nch_mac l=35.0n w=220.0n m=1
MM29 net81 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM28 net85 net9 net81 VDD pch_mac l=35.0n w=100n m=1
MM24 net20 D VDD VDD pch_mac l=35.0n w=275.00n m=1
MM23 net85 SE net20 VDD pch_mac l=35.0n w=275.00n m=1
MM22 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM19 net9 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM21 mq_x clkbb net85 VDD pch_mac l=35.0n w=220.0n m=1
MM20 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM60 net124 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net124 VDD pch_mac l=35.0n w=100n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=310.0n m=1
MM13 mq mq_x VDD VDD pch_mac l=35.0n w=215.00n m=1
MM10 mq SDN VDD VDD pch_mac l=35.0n w=215.00n m=1
MM4 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM8 net77 SDN VDD VDD pch_mac l=35.0n w=100n m=1
MM30 net77 clkbb qf VDD pch_mac l=35.0n w=100n m=1
MM6 net77 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFARD1BWP35 E SE CP SI D Q QN VDD VSS
MM32 net10 qf VSS VSS nch_mac l=35.0n w=160.0n m=1
MM12 net114 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM27 net46 net94 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net21 net110 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net190 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net110 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM31 qf_x clkb net10 VSS nch_mac l=35.0n w=160.0n m=1
MM19 net38 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net94 net114 net38 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net46 SE net82 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM46 mq clkb net46 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM64 mq clkbb net74 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net74 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 net82 net190 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=160.0n m=1
MM23 net94 D net97 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net97 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM25 net102 net190 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net106 net110 net102 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net110 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM11 net114 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM29 qf_x clkbb net126 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM30 net126 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM43 net145 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq clkb net158 VDD pch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net106 net94 net145 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net158 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq clkbb net106 VDD pch_mac l=35.0n w=205.00n m=1
MM17 net177 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net94 E net177 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM21 net94 D net185 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net185 net114 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net190 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFARD2BWP35 E SE CP SI D Q QN VDD VSS
MM24 net109 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net106 D net109 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=160.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM48 net157 net174 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net126 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net126 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM46 mq clkb net154 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM47 net154 SE net157 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net106 net86 net161 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net161 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM31 qf_x clkb net190 VSS nch_mac l=35.0n w=160.0n m=1
MM16 net170 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net174 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net178 net170 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net154 net106 net178 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net86 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM32 net190 qf VSS VSS nch_mac l=35.0n w=160.0n m=1
MM13 net174 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net21 net86 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net106 D net21 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM18 net106 E net30 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net30 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net94 VDD pch_mac l=35.0n w=205.00n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net42 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net94 net106 net61 VDD pch_mac l=35.0n w=170.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net42 VDD pch_mac l=35.0n w=175.00n m=1
MM43 net61 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM30 net85 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM29 qf_x clkbb net85 VDD pch_mac l=35.0n w=175.00n m=1
MM11 net86 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM15 net170 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM26 net94 net170 net98 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net98 net174 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFARD4BWP35 E SE CP SI D Q QN VDD VSS
MM32 net10 qf VSS VSS nch_mac l=35.0n w=175.00n m=1
MM12 net14 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM27 net46 net94 net22 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net22 net30 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net190 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net30 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM31 qf_x clkb net10 VSS nch_mac l=35.0n w=175.00n m=1
MM19 net45 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net94 net14 net45 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net46 SE net49 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=2
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net46 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM64 mq clkbb net73 VSS nch_mac l=35.0n w=130.0n m=1
MM65 net73 mq_x VSS VSS nch_mac l=35.0n w=130.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM48 net49 net190 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=175.00n m=1
MM23 net94 D net98 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net98 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM25 net109 net190 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net106 net30 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net30 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM11 net14 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM29 qf_x clkbb net126 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM30 net126 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM43 net145 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq clkb net137 VDD pch_mac l=35.0n w=130.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM44 net106 net94 net145 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=2
MM60 net137 mq_x VDD VDD pch_mac l=35.0n w=130.0n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM45 mq clkbb net106 VDD pch_mac l=35.0n w=205.00n m=1
MM17 net177 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net94 E net177 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM21 net94 D net186 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net186 net14 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net190 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFCND0BWP35 E SE CP SI D CDN Q QN VDD VSS
MM2 net86 net0274 net0103 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net0103 net0106 net0107 VSS nch_mac l=35.0n w=250.0n m=1
MM0 net0274 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM7 net0107 net174 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM52 net86 SE net154 VSS nch_mac l=35.0n w=100n m=1
MM73 net0106 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM48 net98 E net0107 VSS nch_mac l=35.0n w=145.00n m=1
MM67 net0106 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM69 QN net0106 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net125 mq net126 VSS nch_mac l=35.0n w=100n m=1
MM57 net174 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM64 mq_x clkbb net125 VSS nch_mac l=35.0n w=100n m=1
MM66 net126 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq_x clkb net86 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net150 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM75 net150 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net154 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net86 D net98 VSS nch_mac l=35.0n w=280.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net0274 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 net162 E net0199 VDD pch_mac l=35.0n w=255.00n m=1
MM5 net0199 net0106 net0203 VDD pch_mac l=35.0n w=255.00n m=1
MM42 net162 net174 net186 VDD pch_mac l=35.0n w=100n m=1
MM6 net0203 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net162 VDD pch_mac l=35.0n w=190.0n m=1
MM70 QN net0106 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 net174 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM74 net0106 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net225 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net186 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM61 net225 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net162 D net213 VDD pch_mac l=35.0n w=255.00n m=1
MM68 net0106 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq_x clkb net225 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net213 net0274 net0203 VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt SEDFCND1BWP35 E SE CP SI D CDN Q QN VDD VSS
MM47 net175 D net106 VSS nch_mac l=35.0n w=280.0n m=1
MM51 net107 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net111 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM76 qf_x qf net111 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net175 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net150 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net142 VSS nch_mac l=35.0n w=100n m=1
MM57 net67 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM65 net142 mq net150 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM69 QN net189 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM67 net189 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM48 net106 E net190 VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM73 net189 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM52 net175 SE net107 VSS nch_mac l=35.0n w=100n m=1
MM7 net190 net67 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM0 net95 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM3 net187 net189 net190 VSS nch_mac l=35.0n w=250.0n m=1
MM2 net175 net95 net187 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net34 net95 net90 VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net22 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM68 net189 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM44 net83 D net34 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net22 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM41 net55 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net22 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net189 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM58 net67 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM70 QN net189 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq_x clkbb net83 VDD pch_mac l=35.0n w=190.0n m=1
MM6 net90 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM42 net83 net67 net55 VDD pch_mac l=35.0n w=100n m=1
MM5 net94 net189 net90 VDD pch_mac l=35.0n w=255.00n m=1
MM4 net83 E net94 VDD pch_mac l=35.0n w=255.00n m=1
MM1 net95 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFCND2BWP35 E SE CP SI D CDN Q QN VDD VSS
MM2 net35 net27 net23 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net23 net25 net26 VSS nch_mac l=35.0n w=250.0n m=1
MM0 net27 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM7 net26 net67 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM52 net35 SE net103 VSS nch_mac l=35.0n w=100n m=1
MM73 net25 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM48 net47 E net26 VSS nch_mac l=35.0n w=145.00n m=1
MM67 net25 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM69 QN net25 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net74 mq net66 VSS nch_mac l=35.0n w=100n m=1
MM57 net67 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM64 mq_x clkbb net74 VSS nch_mac l=35.0n w=100n m=1
MM66 net66 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net35 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf net90 VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM75 net90 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM51 net103 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM47 net35 D net47 VSS nch_mac l=35.0n w=280.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net27 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 net135 E net131 VDD pch_mac l=35.0n w=255.00n m=1
MM5 net131 net25 net134 VDD pch_mac l=35.0n w=255.00n m=1
MM42 net135 net67 net138 VDD pch_mac l=35.0n w=100n m=1
MM6 net134 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net135 VDD pch_mac l=35.0n w=190.0n m=1
MM70 QN net25 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM58 net67 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM74 net25 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM60 net159 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM41 net138 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM61 net159 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net135 D net190 VDD pch_mac l=35.0n w=255.00n m=1
MM68 net25 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net159 VDD pch_mac l=35.0n w=120.0n m=1
MM43 net190 net27 net134 VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt SEDFCND4BWP35 E SE CP SI D CDN Q QN VDD VSS
MM41 qf_x qf net0233 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net506 net426 net518 VSS nch_mac l=35.0n w=280.0n m=1
MM14 net518 net520 net521 VSS nch_mac l=35.0n w=250.0n m=1
MM15 net426 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM16 net521 net398 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM17 net506 SE net509 VSS nch_mac l=35.0n w=100n m=1
MM42 net0233 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net520 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM20 net494 E net521 VSS nch_mac l=35.0n w=145.00n m=1
MM21 net520 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM22 QN net520 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM23 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM24 net473 mq net466 VSS nch_mac l=35.0n w=100n m=1
MM25 net398 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM26 mq_x clkbb net473 VSS nch_mac l=35.0n w=100n m=1
MM27 net466 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM28 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 mq_x clkb net506 VSS nch_mac l=35.0n w=185.00n m=1
MM30 qf_x qf net442 VSS nch_mac l=35.0n w=280.0n m=1
MM31 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM32 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM33 net442 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM34 net509 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM35 net506 D net494 VSS nch_mac l=35.0n w=280.0n m=1
MM36 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM37 net426 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM38 net414 E net418 VDD pch_mac l=35.0n w=255.00n m=1
MM39 net418 net520 net421 VDD pch_mac l=35.0n w=255.00n m=1
MM40 net414 net398 net386 VDD pch_mac l=35.0n w=100n m=1
MM54 net421 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM63 mq_x clkbb net414 VDD pch_mac l=35.0n w=190.0n m=1
MM80 QN net520 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM81 net398 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM82 net520 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM83 net353 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM84 net386 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM85 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM86 net353 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM87 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM88 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM89 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM90 net414 D net346 VDD pch_mac l=35.0n w=255.00n m=1
MM91 net520 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM92 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM93 mq_x clkb net353 VDD pch_mac l=35.0n w=120.0n m=1
MM94 net346 net426 net421 VDD pch_mac l=35.0n w=255.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt SEDFCNQD0BWP35 E SE CP SI D CDN Q VDD VSS
MM47 net166 D net101 VSS nch_mac l=35.0n w=280.0n m=1
MM51 net102 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net121 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM76 qf_x qf net121 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net166 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM66 net145 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net142 VSS nch_mac l=35.0n w=100n m=1
MM57 net66 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM65 net142 mq net145 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM67 net180 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM48 net101 E net181 VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM73 net180 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM52 net166 SE net102 VSS nch_mac l=35.0n w=100n m=1
MM7 net181 net66 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM0 net90 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM3 net178 net180 net181 VSS nch_mac l=35.0n w=250.0n m=1
MM2 net166 net90 net178 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net14 net90 net85 VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net58 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM68 net180 clkbb qf VDD pch_mac l=35.0n w=170.0n m=1
MM44 net78 D net14 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM61 net58 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM41 net54 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net58 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net180 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM58 net66 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net78 VDD pch_mac l=35.0n w=190.0n m=1
MM6 net85 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM42 net78 net66 net54 VDD pch_mac l=35.0n w=100n m=1
MM5 net89 net180 net85 VDD pch_mac l=35.0n w=255.00n m=1
MM4 net78 E net89 VDD pch_mac l=35.0n w=255.00n m=1
MM1 net90 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFCNQD1BWP35 E SE CP SI D CDN Q VDD VSS
MM47 net26 D net38 VSS nch_mac l=35.0n w=280.0n m=1
MM51 net29 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net86 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM76 qf_x qf net86 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net26 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net62 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net50 VSS nch_mac l=35.0n w=100n m=1
MM57 net126 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM65 net50 mq net62 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM67 net16 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM48 net38 E net17 VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM73 net16 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM52 net26 SE net29 VSS nch_mac l=35.0n w=100n m=1
MM7 net17 net126 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM0 net102 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM3 net14 net16 net17 VSS nch_mac l=35.0n w=250.0n m=1
MM2 net26 net102 net14 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net165 net102 net113 VDD pch_mac l=35.0n w=255.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net177 VDD pch_mac l=35.0n w=120.0n m=1
MM68 net16 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net114 D net165 VDD pch_mac l=35.0n w=255.00n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=275.00n m=1
MM61 net177 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM41 net138 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net177 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net16 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM58 net126 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net114 VDD pch_mac l=35.0n w=190.0n m=1
MM6 net113 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM42 net114 net126 net138 VDD pch_mac l=35.0n w=100n m=1
MM5 net109 net16 net113 VDD pch_mac l=35.0n w=255.00n m=1
MM4 net114 E net109 VDD pch_mac l=35.0n w=255.00n m=1
MM1 net102 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFCNQD2BWP35 E SE CP SI D CDN Q VDD VSS
MM47 net166 D net154 VSS nch_mac l=35.0n w=280.0n m=1
MM51 net169 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM75 net106 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM76 qf_x qf net106 VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net166 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM66 net130 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net137 VSS nch_mac l=35.0n w=100n m=1
MM57 net138 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM65 net137 mq net130 VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM67 net180 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM48 net154 E net181 VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM73 net180 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM52 net166 SE net169 VSS nch_mac l=35.0n w=100n m=1
MM7 net181 net138 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM0 net90 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM3 net185 net180 net181 VSS nch_mac l=35.0n w=250.0n m=1
MM2 net166 net90 net185 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM43 net14 net90 net85 VDD pch_mac l=35.0n w=255.00n m=1
MM79 mq_x clkb net21 VDD pch_mac l=35.0n w=120.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM68 net180 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM44 net78 D net14 VDD pch_mac l=35.0n w=255.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM78 qf_x CDN VDD VDD pch_mac l=35.0n w=275.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM61 net21 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM41 net81 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM60 net21 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM74 net180 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM58 net138 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM45 mq_x clkbb net78 VDD pch_mac l=35.0n w=190.0n m=1
MM6 net85 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM42 net78 net138 net81 VDD pch_mac l=35.0n w=100n m=1
MM5 net82 net180 net85 VDD pch_mac l=35.0n w=255.00n m=1
MM4 net78 E net82 VDD pch_mac l=35.0n w=255.00n m=1
MM1 net90 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFCNQD4BWP35 E SE CP SI D CDN Q VDD VSS
MM1 qf_x qf net0123 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0123 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM35 net78 D net13 VSS nch_mac l=35.0n w=280.0n m=1
MM34 net81 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM33 net33 CDN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM32 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 mq mq_x VSS VSS nch_mac l=35.0n w=260.0n m=1
MM30 qf_x qf net33 VSS nch_mac l=35.0n w=280.0n m=1
MM29 mq_x clkb net78 VSS nch_mac l=35.0n w=185.00n m=1
MM28 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM27 net42 CDN VSS VSS nch_mac l=35.0n w=100n m=1
MM26 mq_x clkbb net49 VSS nch_mac l=35.0n w=100n m=1
MM25 net50 SE VSS VSS nch_mac l=35.0n w=145.00n m=1
MM24 net49 mq net42 VSS nch_mac l=35.0n w=100n m=1
MM23 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM21 net92 clkb qf VSS nch_mac l=35.0n w=120.0n m=1
MM20 net13 E net93 VSS nch_mac l=35.0n w=145.00n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=150.0n m=1
MM18 net92 qf_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM17 net78 SE net81 VSS nch_mac l=35.0n w=100n m=1
MM16 net93 net50 VSS VSS nch_mac l=35.0n w=145.00n m=1
MM15 net86 E VSS VSS nch_mac l=35.0n w=275.00n m=1
MM14 net97 net92 net93 VSS nch_mac l=35.0n w=250.0n m=1
MM13 net78 net86 net97 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=275.00n m=1
MM94 net121 net86 net173 VDD pch_mac l=35.0n w=255.00n m=1
MM93 mq_x clkb net109 VDD pch_mac l=35.0n w=120.0n m=1
MM92 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM91 net92 clkbb qf VDD pch_mac l=35.0n w=275.00n m=1
MM90 net166 D net121 VDD pch_mac l=35.0n w=255.00n m=1
MM89 qf_x CDN VDD VDD pch_mac l=35.0n w=340.0n m=2
MM88 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM87 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM86 net109 mq VDD VDD pch_mac l=35.0n w=120.0n m=1
MM85 mq mq_x VDD VDD pch_mac l=35.0n w=255.00n m=1
MM84 net169 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM83 net109 CDN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM82 net92 qf_x VDD VDD pch_mac l=35.0n w=275.00n m=1
MM81 net50 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM63 mq_x clkbb net166 VDD pch_mac l=35.0n w=190.0n m=1
MM54 net173 SE VDD VDD pch_mac l=35.0n w=270.0n m=1
MM40 net166 net50 net169 VDD pch_mac l=35.0n w=100n m=1
MM39 net177 net92 net173 VDD pch_mac l=35.0n w=255.00n m=1
MM38 net166 E net177 VDD pch_mac l=35.0n w=255.00n m=1
MM37 net86 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM36 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFD0BWP35 E SE CP SI D Q QN VDD VSS
MM32 net0450 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM12 net30 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM27 net122 net138 net114 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net114 net18 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net154 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net18 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM31 qf_x clkb net0450 VSS nch_mac l=35.0n w=100n m=1
MM19 net150 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net138 net30 net150 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net122 SE net126 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq clkb net122 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net194 VSS nch_mac l=35.0n w=100n m=1
MM65 net194 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM48 net126 net154 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net138 D net134 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net134 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM25 net13 net154 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net10 net18 net13 VDD pch_mac l=35.0n w=170.0n m=1
MM11 net30 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net18 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM29 qf_x clkbb net0351 VDD pch_mac l=35.0n w=295.00n m=1
MM30 net0351 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM43 net54 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net94 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM44 net10 net138 net54 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM60 net94 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM45 mq clkbb net10 VDD pch_mac l=35.0n w=200n m=1
MM17 net38 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net138 E net38 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net138 D net22 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net22 net30 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net154 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFD4BWP35 E SE CP SI D Q QN VDD VSS
MM32 net10 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM12 net14 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM27 net46 net94 net22 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net22 net30 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net190 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net30 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM31 qf_x clkb net10 VSS nch_mac l=35.0n w=100n m=1
MM19 net45 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net94 net14 net45 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net46 SE net49 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=170.0n m=2
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net46 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net73 VSS nch_mac l=35.0n w=100n m=1
MM65 net73 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM48 net49 net190 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM23 net94 D net98 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net98 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM25 net109 net190 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net106 net30 net109 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net30 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM11 net14 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM29 qf_x clkbb net126 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=340.0n m=1
MM30 net126 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM43 net145 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net137 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM44 net106 net94 net145 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=170.0n m=2
MM60 net137 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM45 mq clkbb net106 VDD pch_mac l=35.0n w=200n m=1
MM17 net177 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net94 E net177 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net94 D net186 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net186 net14 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net190 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFKCND0BWP35 SI D E SE CP CN Q QN VDD VSS
MM59 net305 net193 net285 VSS nch_mac l=35.0n w=175.00n m=1
MM58 net285 net353 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM57 net289 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM54 net193 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM52 net297 net294 net347 VSS nch_mac l=35.0n w=210.0n m=1
MM51 net345 net289 net297 VSS nch_mac l=35.0n w=210.0n m=1
MM42 net305 SE net337 VSS nch_mac l=35.0n w=100n m=1
MM41 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM39 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM38 mq_x clkb net305 VSS nch_mac l=35.0n w=185.00n m=1
MM37 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM36 mq_x clkbb net333 VSS nch_mac l=35.0n w=100n m=1
MM35 net333 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM34 net337 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM33 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM32 net345 D net349 VSS nch_mac l=35.0n w=280.0n m=1
MM31 net349 E net347 VSS nch_mac l=35.0n w=280.0n m=1
MM30 net353 net345 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 net347 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net294 qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net294 clkb qf VSS nch_mac l=35.0n w=140.0n m=1
MM10 QN net294 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM93 net187 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM92 net189 net193 net187 VDD pch_mac l=35.0n w=100n m=1
MM91 net193 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM90 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM89 net285 net353 VDD VDD pch_mac l=35.0n w=275.00n m=1
MM88 mq_x clkb net225 VDD pch_mac l=35.0n w=100n m=1
MM87 net189 SE net285 VDD pch_mac l=35.0n w=275.00n m=1
MM86 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM85 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM84 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM83 net225 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM82 mq_x clkbb net189 VDD pch_mac l=35.0n w=195.00n m=1
MM81 net235 net294 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM80 net345 E net235 VDD pch_mac l=35.0n w=235.00n m=1
MM78 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM75 net345 D net243 VDD pch_mac l=35.0n w=195.00n m=1
MM70 net243 net289 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM69 net289 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM68 net345 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM67 net353 net345 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM66 net294 qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM63 net294 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM62 QN net294 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM61 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFKCND1BWP35 SI D E SE CP CN Q QN VDD VSS
MM27 net131 net179 net0285 VSS nch_mac l=35.0n w=175.00n m=1
MM28 net0285 net19 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net79 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net179 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM19 net130 net125 net178 VSS nch_mac l=35.0n w=210.0n m=1
MM20 net171 net79 net130 VSS nch_mac l=35.0n w=210.0n m=1
MM47 net131 SE net163 VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net131 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net159 VSS nch_mac l=35.0n w=100n m=1
MM65 net159 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM48 net163 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM23 net171 D net175 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net175 E net178 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net19 net171 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net178 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net125 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net125 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM73 QN net125 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net18 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM26 net15 net179 net18 VDD pch_mac l=35.0n w=100n m=1
MM15 net179 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM43 net0285 net19 VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net51 VDD pch_mac l=35.0n w=100n m=1
MM44 net15 SE net0285 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM60 net51 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net15 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net66 net125 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM18 net171 E net66 VDD pch_mac l=35.0n w=235.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net171 D net74 VDD pch_mac l=35.0n w=195.00n m=1
MM22 net74 net79 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM13 net79 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net171 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net19 net171 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net125 qf_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM7 net125 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM74 QN net125 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFKCND2BWP35 SI D E SE CP CN Q QN VDD VSS
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM73 QN net89 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net89 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM4 net89 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net38 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net91 net39 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net42 E net38 VSS nch_mac l=35.0n w=280.0n m=1
MM23 net39 D net42 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net82 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM65 net58 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net58 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net79 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net79 SE net82 VSS nch_mac l=35.0n w=100n m=1
MM20 net39 net95 net87 VSS nch_mac l=35.0n w=210.0n m=1
MM19 net87 net89 net38 VSS nch_mac l=35.0n w=210.0n m=1
MM16 net0310 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM14 net95 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net0261 net91 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net79 net0310 net0261 VSS nch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM74 QN net89 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net89 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM5 net89 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net91 net39 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net39 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net95 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net135 net95 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM21 net39 D net135 VDD pch_mac l=35.0n w=195.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net39 E net151 VDD pch_mac l=35.0n w=235.00n m=1
MM17 net151 net89 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM45 mq_x clkbb net195 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net159 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net195 SE net0261 VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net159 VDD pch_mac l=35.0n w=100n m=1
MM43 net0261 net91 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM15 net0310 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM26 net195 net0310 net198 VDD pch_mac l=35.0n w=100n m=1
MM25 net198 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SEDFKCND4BWP35 SI D E SE CP CN Q QN VDD VSS
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM73 QN net185 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net185 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net185 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM0 net134 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net27 net135 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net131 E net134 VSS nch_mac l=35.0n w=280.0n m=1
MM23 net135 D net131 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net178 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM65 net147 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net147 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net175 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net175 SE net178 VSS nch_mac l=35.0n w=100n m=1
MM20 net135 net35 net182 VSS nch_mac l=35.0n w=210.0n m=1
MM19 net182 net185 net134 VSS nch_mac l=35.0n w=210.0n m=1
MM16 net99 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM14 net35 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net86 net27 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net175 net99 net86 VSS nch_mac l=35.0n w=175.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM74 QN net185 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM7 net185 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM5 net185 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net27 net135 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net135 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net35 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net39 net35 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM21 net135 D net39 VDD pch_mac l=35.0n w=195.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net135 E net54 VDD pch_mac l=35.0n w=235.00n m=1
MM17 net54 net185 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM45 mq_x clkbb net95 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net82 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net82 VDD pch_mac l=35.0n w=100n m=1
MM44 net95 SE net86 VDD pch_mac l=35.0n w=275.00n m=1
MM43 net86 net27 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM26 net95 net99 net103 VDD pch_mac l=35.0n w=100n m=1
MM15 net99 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM25 net103 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SEDFKCNQD0BWP35 SI D E SE CP CN Q VDD VSS
MM10 net0633 Q VSS VSS nch_mac l=35.0n w=120.0n m=1
MM9 qf_x clkb net0633 VSS nch_mac l=35.0n w=120.0n m=1
MM27 net0607 net0567 net0627 VSS nch_mac l=35.0n w=175.00n m=1
MM28 net0627 net0375 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net0383 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net0443 SI VSS VSS nch_mac l=35.0n w=175.00n m=1
MM19 net0609 Q net0561 VSS nch_mac l=35.0n w=210.0n m=1
MM20 net0567 net0383 net0609 VSS nch_mac l=35.0n w=210.0n m=1
MM47 net0607 SE net0575 VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq clkb net0607 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net0579 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net0579 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM48 net0575 net0443 VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM23 net0567 D net0563 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net0563 E net0561 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0375 SE VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net0561 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkbb net0455 VDD pch_mac l=35.0n w=100n m=1
MM5 net0455 Q VDD VDD pch_mac l=35.0n w=100n m=1
MM25 net0445 net0443 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0447 net0375 net0445 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net0443 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=275.00n m=1
MM43 net0425 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq clkb net0411 VDD pch_mac l=35.0n w=100n m=1
MM44 net0447 net0567 net0425 VDD pch_mac l=35.0n w=170.0n m=1
MM77 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net0411 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq clkbb net0447 VDD pch_mac l=35.0n w=205.00n m=1
MM17 net0403 Q VDD VDD pch_mac l=35.0n w=215.00n m=1
MM18 net0567 E net0403 VDD pch_mac l=35.0n w=215.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net0567 D net0389 VDD pch_mac l=35.0n w=195.00n m=1
MM22 net0389 net0383 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM13 net0383 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net0567 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net0375 SE VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFKCNQD1BWP35 SI D E SE CP CN Q VDD VSS
MM4 net124 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net181 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net182 net174 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net177 E net181 VSS nch_mac l=35.0n w=280.0n m=1
MM23 net174 D net177 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net166 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM65 net157 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net157 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net130 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net130 SE net166 VSS nch_mac l=35.0n w=100n m=1
MM20 net174 net82 net129 VSS nch_mac l=35.0n w=210.0n m=1
MM19 net129 net124 net181 VSS nch_mac l=35.0n w=210.0n m=1
MM16 net114 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM6 net124 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM14 net82 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net106 net182 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net130 net114 net106 VSS nch_mac l=35.0n w=175.00n m=1
MM26 net14 net114 net10 VDD pch_mac l=35.0n w=100n m=1
MM25 net10 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM7 net124 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM5 net124 qf_x VDD VDD pch_mac l=35.0n w=310.0n m=1
MM3 net182 net174 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net174 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net82 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net78 net82 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM21 net174 D net78 VDD pch_mac l=35.0n w=195.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net174 E net69 VDD pch_mac l=35.0n w=235.00n m=1
MM17 net69 net124 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM45 mq_x clkbb net14 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net54 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net14 SE net106 VDD pch_mac l=35.0n w=275.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM79 mq_x clkb net54 VDD pch_mac l=35.0n w=100n m=1
MM43 net106 net182 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM15 net114 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
.ends
.subckt SEDFKCNQD2BWP35 SI D E SE CP CN Q VDD VSS
MM4 net80 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net25 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net182 net26 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net29 E net25 VSS nch_mac l=35.0n w=280.0n m=1
MM23 net26 D net29 VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM48 net34 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net49 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq_x clkbb net49 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq_x clkb net70 VSS nch_mac l=35.0n w=185.00n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net70 SE net34 VSS nch_mac l=35.0n w=100n m=1
MM20 net26 net118 net78 VSS nch_mac l=35.0n w=210.0n m=1
MM19 net78 net80 net25 VSS nch_mac l=35.0n w=210.0n m=1
MM6 net80 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM16 net0298 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM14 net118 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net0362 net182 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM27 net70 net0298 net0362 VSS nch_mac l=35.0n w=175.00n m=1
MM7 net80 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
MM5 net80 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net182 net26 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net26 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net118 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net122 net118 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM21 net26 D net122 VDD pch_mac l=35.0n w=195.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net26 E net138 VDD pch_mac l=35.0n w=235.00n m=1
MM17 net138 net80 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM45 mq_x clkbb net186 VDD pch_mac l=35.0n w=195.00n m=1
MM60 net146 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net186 SE net0362 VDD pch_mac l=35.0n w=275.00n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq_x clkb net146 VDD pch_mac l=35.0n w=100n m=1
MM43 net0362 net182 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM15 net0298 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
MM26 net186 net0298 net190 VDD pch_mac l=35.0n w=100n m=1
MM25 net190 SI VDD VDD pch_mac l=35.0n w=100n m=1
.ends
.subckt SEDFKCNQD4BWP35 SI D E SE CP CN Q VDD VSS
MM27 net130 net18 net106 VSS nch_mac l=35.0n w=175.00n m=1
MM28 net106 net0206 VSS VSS nch_mac l=35.0n w=175.00n m=1
MM14 net82 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 net18 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM6 net124 clkb qf VSS nch_mac l=35.0n w=265.00n m=1
MM19 net129 net124 net181 VSS nch_mac l=35.0n w=210.0n m=1
MM20 net174 net82 net129 VSS nch_mac l=35.0n w=210.0n m=1
MM47 net130 SE net166 VSS nch_mac l=35.0n w=100n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq mq_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf_x qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM46 mq_x clkb net130 VSS nch_mac l=35.0n w=185.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq_x clkbb net158 VSS nch_mac l=35.0n w=100n m=1
MM65 net158 mq VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM48 net166 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf clkbb mq VSS nch_mac l=35.0n w=265.00n m=1
MM23 net174 D net178 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net178 E net181 VSS nch_mac l=35.0n w=280.0n m=1
MM2 net0206 net174 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net181 CN VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net124 qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net17 SI VDD VDD pch_mac l=35.0n w=100n m=1
MM26 net14 net18 net17 VDD pch_mac l=35.0n w=100n m=1
MM15 net18 SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMSLTp1 qf clkb mq VDD pch_mac l=35.0n w=305.00n m=1
MM43 net106 net0206 VDD VDD pch_mac l=35.0n w=275.00n m=1
MM79 mq_x clkb net33 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM44 net14 SE net106 VDD pch_mac l=35.0n w=275.00n m=1
MM77 qf_x qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq mq_x VDD VDD pch_mac l=35.0n w=305.00n m=1
MM60 net33 mq VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq_x clkbb net14 VDD pch_mac l=35.0n w=195.00n m=1
MM17 net69 net124 VDD VDD pch_mac l=35.0n w=235.00n m=1
MM18 net174 E net69 VDD pch_mac l=35.0n w=235.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net174 D net77 VDD pch_mac l=35.0n w=195.00n m=1
MM22 net77 net82 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM13 net82 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net174 CN VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net0206 net174 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM5 net124 qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net124 clkbb qf VDD pch_mac l=35.0n w=305.00n m=1
.ends
.subckt SEDFQARD1BWP35 E SE CP SI D Q VDD VSS
MM10 net97 qf VSS VSS nch_mac l=35.0n w=160.0n m=1
MM9 qf_x clkb net97 VSS nch_mac l=35.0n w=160.0n m=1
MM27 net129 net169 net108 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net108 net89 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net85 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net25 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net121 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net169 net85 net121 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net129 SE net161 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM46 mq clkb net129 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM64 mq clkbb net157 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net157 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM48 net161 net25 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=160.0n m=1
MM23 net169 D net173 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net173 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net89 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkbb net13 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net13 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net24 net25 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net21 net89 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net25 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM43 net44 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq clkb net57 VDD pch_mac l=35.0n w=175.00n m=1
MM44 net21 net169 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM60 net57 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM45 mq clkbb net21 VDD pch_mac l=35.0n w=205.00n m=1
MM17 net72 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net169 E net72 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM21 net169 D net81 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net81 net85 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net85 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM3 net89 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFQARD2BWP35 E SE CP SI D Q VDD VSS
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net101 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM24 net24 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net21 D net24 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=160.0n m=1
MM48 net29 net165 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net40 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net40 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM46 mq clkb net61 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM47 net61 SE net29 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net21 net105 net69 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net69 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM16 net165 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net105 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM28 net81 net101 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net61 net21 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM9 qf_x clkb net93 VSS nch_mac l=35.0n w=160.0n m=1
MM10 net93 qf VSS VSS nch_mac l=35.0n w=160.0n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net101 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM13 net105 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM22 net116 net105 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net21 D net116 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM18 net21 E net125 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net125 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net169 VDD pch_mac l=35.0n w=205.00n m=1
MM60 net156 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 net21 net157 VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net156 VDD pch_mac l=35.0n w=175.00n m=1
MM43 net157 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM15 net165 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net169 net101 net172 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net172 net165 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net177 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM4 qf_x clkbb net177 VDD pch_mac l=35.0n w=175.00n m=1
.ends
.subckt SEDFQARD4BWP35 E SE CP SI D Q VDD VSS
MM10 net104 qf VSS VSS nch_mac l=35.0n w=175.00n m=1
MM9 qf_x clkb net104 VSS nch_mac l=35.0n w=175.00n m=1
MM27 net129 net169 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net109 net177 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net113 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net117 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net128 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net169 net113 net128 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net129 SE net161 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=290.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=175.00n m=2
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net129 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=290.0n m=1
MM64 mq clkbb net157 VSS nch_mac l=35.0n w=130.0n m=1
MM65 net157 mq_x VSS VSS nch_mac l=35.0n w=130.0n m=1
MM48 net161 net117 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=175.00n m=1
MM23 net169 D net173 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net173 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net177 SE VSS VSS nch_mac l=35.0n w=160.0n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 qf_x clkbb net13 VDD pch_mac l=35.0n w=175.00n m=1
MM5 net13 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net24 net117 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net21 net177 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net117 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM43 net44 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM79 mq clkb net40 VDD pch_mac l=35.0n w=130.0n m=1
MM44 net21 net169 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=310.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=175.00n m=2
MM60 net40 mq_x VDD VDD pch_mac l=35.0n w=130.0n m=1
MM45 mq clkbb net21 VDD pch_mac l=35.0n w=205.00n m=1
MM17 net72 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net169 E net72 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=310.0n m=1
MM21 net169 D net81 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net81 net113 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net113 E VDD VDD pch_mac l=35.0n w=140.0n m=1
MM3 net177 SE VDD VDD pch_mac l=35.0n w=285.00n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt SEDFQD0BWP35 E SE CP SI D Q VDD VSS
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net101 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM24 net17 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net21 D net17 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM48 net29 net165 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net40 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net40 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq clkb net61 VSS nch_mac l=35.0n w=190.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM47 net61 SE net29 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net21 net105 net69 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net69 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM16 net165 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net105 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM28 net88 net101 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net61 net21 net88 VSS nch_mac l=35.0n w=140.0n m=1
MM9 qf_x clkb net93 VSS nch_mac l=35.0n w=100n m=1
MM10 net93 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net101 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM13 net105 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net116 net105 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net21 D net116 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 net21 E net124 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net124 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net169 VDD pch_mac l=35.0n w=200n m=1
MM60 net133 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM44 net169 net21 net157 VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net133 VDD pch_mac l=35.0n w=100n m=1
MM43 net157 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM15 net165 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net169 net101 net173 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net173 net165 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net184 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 qf_x clkbb net184 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQD4BWP35 E SE CP SI D Q VDD VSS
MM10 net104 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf_x clkb net104 VSS nch_mac l=35.0n w=100n m=1
MM27 net129 net169 net109 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net109 net177 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net113 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net117 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net128 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net169 net113 net128 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net129 SE net161 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=170.0n m=2
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net129 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net157 VSS nch_mac l=35.0n w=100n m=1
MM65 net157 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM48 net161 net117 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM23 net169 D net173 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net173 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net177 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 qf_x clkbb net13 VDD pch_mac l=35.0n w=120.0n m=1
MM5 net13 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM25 net24 net117 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net21 net177 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net117 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=340.0n m=1
MM43 net44 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net40 VDD pch_mac l=35.0n w=100n m=1
MM44 net21 net169 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=170.0n m=2
MM60 net40 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq clkbb net21 VDD pch_mac l=35.0n w=200n m=1
MM17 net72 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net169 E net72 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net169 D net81 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net81 net113 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net113 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net177 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt SEDFQND0BWP35 E SE CP SI D QN VDD VSS
MM10 net108 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf_x clkb net108 VSS nch_mac l=35.0n w=100n m=1
MM27 net133 net173 net113 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net113 net93 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net117 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net29 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net132 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net173 net117 net132 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net133 SE net165 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=140.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net133 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net160 VSS nch_mac l=35.0n w=100n m=1
MM65 net160 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM48 net165 net29 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM23 net173 D net177 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net177 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net93 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM0 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 qf_x clkbb net17 VDD pch_mac l=35.0n w=295.00n m=1
MM5 net17 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM25 net28 net29 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net25 net93 net28 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net29 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM43 net48 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net44 VDD pch_mac l=35.0n w=100n m=1
MM44 net25 net173 net48 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM60 net44 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq clkbb net25 VDD pch_mac l=35.0n w=200n m=1
MM17 net76 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net173 E net76 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net173 D net84 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net84 net117 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net117 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net93 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM1 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFQNXD0BWP35 E SE CP SI D QN VDD VSS
MM31 net0440 net11 net137 VSS nch_mac l=35.0n w=155.00n m=1
MM29 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net9 net11 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net20 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net17 SE net20 VSS nch_mac l=35.0n w=100n m=1
MM0 net0440 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net21 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net11 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM65 net76 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net76 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq net17 net80 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net60 net11 net45 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net45 D net17 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net137 net21 net17 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net113 E net9 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net80 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM32 net0440 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM7 VSS E net60 VSS nch_mac l=35.0n w=155.00n m=1
MM33 net0440 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM28 net108 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net17 net11 net108 VDD pch_mac l=35.0n w=120.0n m=1
MM30 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net11 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM1 net0440 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net21 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net113 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net113 net11 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 VDD net113 net129 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net129 D net17 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net17 net156 VDD pch_mac l=35.0n w=155.00n m=1
MM60 net157 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net156 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net157 VDD pch_mac l=35.0n w=155.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM26 net0440 E net144 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net144 SE net17 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQNXD1BWP35 E SE CP SI D QN VDD VSS
MM7 VSS E net100 VSS nch_mac l=35.0n w=155.00n m=1
MM32 net185 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM27 net140 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net109 E net112 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net188 net161 net169 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net124 D net169 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net100 net179 net124 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq net169 net140 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM24 net179 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net161 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net185 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net169 SE net173 VSS nch_mac l=35.0n w=100n m=1
MM12 net173 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net112 net179 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 net185 net179 net188 VSS nch_mac l=35.0n w=155.00n m=1
MM25 net16 SE net169 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net185 E net16 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM79 mq clkb net41 VDD pch_mac l=35.0n w=155.00n m=1
MM44 net48 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM60 net41 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq net169 net48 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net56 D net169 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net109 net56 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net109 net179 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net109 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net161 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net185 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM30 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net169 net179 net85 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net85 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM33 net185 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM34 net179 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQNXD2BWP35 E SE CP SI D QN VDD VSS
MM31 net9 net19 net12 VSS nch_mac l=35.0n w=155.00n m=1
MM29 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net17 net19 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net28 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net113 SE net28 VSS nch_mac l=35.0n w=100n m=1
MM0 net9 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net125 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net19 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM65 net45 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net45 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq net113 net60 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM20 net73 net19 net77 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net77 D net113 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net12 net125 net113 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net85 E net17 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net60 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM32 net9 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM7 VSS E net73 VSS nch_mac l=35.0n w=155.00n m=1
MM34 net19 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM33 net9 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM28 net116 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net113 net19 net116 VDD pch_mac l=35.0n w=120.0n m=1
MM30 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net9 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net125 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net85 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net85 net19 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 VDD net85 net145 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net145 D net113 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net113 net169 VDD pch_mac l=35.0n w=155.00n m=1
MM60 net176 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net176 VDD pch_mac l=35.0n w=155.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM26 net9 E net185 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net185 SE net113 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQNXD4BWP35 E SE CP SI D QN VDD VSS
MM7 VSS E net121 VSS nch_mac l=35.0n w=155.00n m=1
MM32 net185 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM27 net105 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net109 E net112 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net188 net161 net81 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net124 D net81 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net121 net179 net124 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM46 mq net81 net105 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM24 net179 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net161 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net185 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net81 SE net173 VSS nch_mac l=35.0n w=100n m=1
MM12 net173 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net112 net179 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM31 net185 net179 net188 VSS nch_mac l=35.0n w=155.00n m=1
MM25 net9 SE net81 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net185 E net9 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM79 mq clkb net41 VDD pch_mac l=35.0n w=155.00n m=1
MM44 net48 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM60 net41 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq net81 net48 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net56 D net81 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net109 net56 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net109 net179 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net109 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net161 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net185 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM30 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM21 net81 net179 net84 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net84 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM33 net185 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM34 net179 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQXD0BWP35 E SE CP SI D Q VDD VSS
MM7 VSS E net121 VSS nch_mac l=35.0n w=155.00n m=1
MM32 net185 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM27 net140 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net65 E net177 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net188 net161 net85 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net124 D net85 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net121 net179 net124 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq net85 net140 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM64 mq clkbb net149 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net149 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM24 net179 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net161 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net185 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net85 SE net173 VSS nch_mac l=35.0n w=100n m=1
MM12 net173 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net177 net179 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net185 net179 net188 VSS nch_mac l=35.0n w=155.00n m=1
MM25 net16 SE net85 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net185 E net16 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM79 mq clkb net41 VDD pch_mac l=35.0n w=155.00n m=1
MM44 net48 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM60 net41 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq net85 net48 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net56 D net85 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net65 net56 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net65 net179 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net65 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net161 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net185 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM34 net179 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM21 net85 net179 net89 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net89 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM33 net185 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
.ends
.subckt SEDFQXD1BWP35 E SE CP SI D Q VDD VSS
MM31 net9 net19 net12 VSS nch_mac l=35.0n w=155.00n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net88 net19 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net28 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net113 SE net28 VSS nch_mac l=35.0n w=100n m=1
MM0 net9 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net125 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net19 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM65 net52 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net52 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq net113 net89 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM20 net100 net19 net77 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net77 D net113 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net12 net125 net113 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net129 E net88 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net89 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM32 net9 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM7 VSS E net100 VSS nch_mac l=35.0n w=155.00n m=1
MM34 net19 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM33 net9 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM28 net116 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net113 net19 net116 VDD pch_mac l=35.0n w=120.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net9 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net125 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net129 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net129 net19 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 VDD net129 net145 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net145 D net113 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net113 net152 VDD pch_mac l=35.0n w=155.00n m=1
MM60 net153 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net152 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net153 VDD pch_mac l=35.0n w=155.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM26 net9 E net184 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net184 SE net113 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQXD2BWP35 E SE CP SI D Q VDD VSS
MM7 VSS E net121 VSS nch_mac l=35.0n w=155.00n m=1
MM32 net185 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM27 net105 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net109 E net177 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net188 net161 net169 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net124 D net169 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net121 net179 net124 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq net169 net105 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM64 mq clkbb net148 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net148 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=275.00n m=1
MM24 net179 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net161 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net185 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net169 SE net172 VSS nch_mac l=35.0n w=100n m=1
MM12 net172 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net177 net179 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM31 net185 net179 net188 VSS nch_mac l=35.0n w=155.00n m=1
MM25 net16 SE net169 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net185 E net16 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=245.00n m=1
MM79 mq clkb net24 VDD pch_mac l=35.0n w=155.00n m=1
MM44 net48 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM60 net24 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq net169 net48 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net56 D net169 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net109 net56 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net109 net179 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net109 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net161 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net185 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM21 net169 net179 net85 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net85 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM33 net185 clkbb qf_x VDD pch_mac l=35.0n w=245.00n m=1
MM34 net179 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQXD4BWP35 E SE CP SI D Q VDD VSS
MM31 net9 net19 net12 VSS nch_mac l=35.0n w=155.00n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM6 net88 net19 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net28 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net25 SE net28 VSS nch_mac l=35.0n w=100n m=1
MM0 net9 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net125 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net19 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=280.0n m=1
MM65 net52 mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
MM64 mq clkbb net52 VSS nch_mac l=35.0n w=150.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq net25 net89 VSS nch_mac l=35.0n w=150.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM20 net73 net19 net76 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net76 D net25 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net12 net125 net25 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net129 E net88 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net89 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM32 net9 clkb qf_x VSS nch_mac l=35.0n w=100n m=1
MM7 VSS E net73 VSS nch_mac l=35.0n w=155.00n m=1
MM34 net19 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM33 net9 clkbb qf_x VDD pch_mac l=35.0n w=120.0n m=1
MM28 net116 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net25 net19 net116 VDD pch_mac l=35.0n w=120.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM1 net9 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net125 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net129 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net129 net19 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 VDD net129 net145 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net145 D net25 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net25 net169 VDD pch_mac l=35.0n w=175.00n m=1
MM60 net153 mq_x VDD VDD pch_mac l=35.0n w=175.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=340.0n m=2
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net153 VDD pch_mac l=35.0n w=175.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=340.0n m=1
MM26 net9 E net185 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net185 SE net25 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFXD0BWP35 E SE CP SI D Q QN VDD VSS
MM15 QN qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net22 net32 net94 VSS nch_mac l=35.0n w=155.00n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net101 net32 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net41 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net38 SE net41 VSS nch_mac l=35.0n w=100n m=1
MM0 net22 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net46 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net32 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=215.00n m=1
MM65 net65 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net65 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=140.0n m=1
MM46 mq net38 net73 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=140.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=215.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=140.0n m=1
MM20 net86 net32 net89 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net89 D net38 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net94 net46 net38 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net98 E net101 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net73 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM4 net18 qf VSS VSS nch_mac l=35.0n w=215.00n m=1
MM7 VSS E net86 VSS nch_mac l=35.0n w=155.00n m=1
MM5 qf_x clkb net18 VSS nch_mac l=35.0n w=215.00n m=1
MM23 QN qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net117 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM10 qf_x clkbb net117 VDD pch_mac l=35.0n w=175.00n m=1
MM28 net129 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net38 net32 net129 VDD pch_mac l=35.0n w=120.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net32 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM1 net22 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net46 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net98 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net98 net32 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM18 VDD net98 net162 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net162 D net38 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net38 net169 VDD pch_mac l=35.0n w=155.00n m=1
MM60 net170 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM44 net169 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net170 VDD pch_mac l=35.0n w=155.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM26 net22 E net201 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net201 SE net38 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFXD1BWP35 E SE CP SI D Q QN VDD VSS
MM5 qf_x clkb net114 VSS nch_mac l=35.0n w=215.00n m=1
MM4 net114 qf VSS VSS nch_mac l=35.0n w=215.00n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 VSS E net138 VSS nch_mac l=35.0n w=155.00n m=1
MM27 net157 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net126 E net194 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net130 net178 net186 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net141 D net186 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net138 net196 net141 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=215.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq net186 net157 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM64 mq clkbb net165 VSS nch_mac l=35.0n w=175.00n m=1
MM65 net165 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=215.00n m=1
MM24 net196 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net178 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net202 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net186 SE net190 VSS nch_mac l=35.0n w=100n m=1
MM12 net190 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net194 net196 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 net202 net196 net130 VSS nch_mac l=35.0n w=155.00n m=1
MM23 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 qf_x clkbb net18 VDD pch_mac l=35.0n w=175.00n m=1
MM9 net18 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM25 net29 SE net186 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net202 E net29 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net54 VDD pch_mac l=35.0n w=155.00n m=1
MM44 net61 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM60 net54 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq net186 net61 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net62 D net186 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net126 net62 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net126 net196 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net126 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net178 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net202 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net186 net196 net98 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net98 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM34 net196 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFXD2BWP35 E SE CP SI D Q QN VDD VSS
MM4 net21 qf VSS VSS nch_mac l=35.0n w=215.00n m=1
MM5 qf_x clkb net21 VSS nch_mac l=35.0n w=215.00n m=1
MM31 net22 net32 net94 VSS nch_mac l=35.0n w=155.00n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM6 net101 net32 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM12 net41 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM11 net130 SE net41 VSS nch_mac l=35.0n w=100n m=1
MM0 net22 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM2 net46 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM24 net32 SE VSS VSS nch_mac l=35.0n w=100n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=215.00n m=1
MM65 net65 mq_x VSS VSS nch_mac l=35.0n w=175.00n m=1
MM64 mq clkbb net65 VSS nch_mac l=35.0n w=175.00n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM46 mq net130 net102 VSS nch_mac l=35.0n w=175.00n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=215.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM20 net86 net32 net90 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net90 D net130 VSS nch_mac l=35.0n w=155.00n m=1
MM16 net94 net46 net130 VSS nch_mac l=35.0n w=155.00n m=1
MM14 net146 E net101 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net102 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM7 VSS E net86 VSS nch_mac l=35.0n w=155.00n m=1
MM15 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM9 net121 qf VDD VDD pch_mac l=35.0n w=175.00n m=1
MM10 qf_x clkbb net121 VDD pch_mac l=35.0n w=175.00n m=1
MM23 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM34 net32 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
MM28 net133 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM21 net130 net32 net133 VDD pch_mac l=35.0n w=120.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 net22 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM3 net46 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM13 net146 E VDD VDD pch_mac l=35.0n w=100n m=1
MM22 net146 net32 VDD VDD pch_mac l=35.0n w=100n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 VDD net146 net162 VDD pch_mac l=35.0n w=180.0n m=1
MM17 net162 D net130 VDD pch_mac l=35.0n w=180.0n m=1
MM45 mq net130 net169 VDD pch_mac l=35.0n w=155.00n m=1
MM60 net170 mq_x VDD VDD pch_mac l=35.0n w=155.00n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=155.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM79 mq clkb net170 VDD pch_mac l=35.0n w=155.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=175.00n m=1
MM26 net22 E net202 VDD pch_mac l=35.0n w=120.0n m=1
MM25 net202 SE net130 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFXD4BWP35 E SE CP SI D Q QN VDD VSS
MM5 qf_x clkb net109 VSS nch_mac l=35.0n w=100n m=1
MM4 net109 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM23 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 VSS E net138 VSS nch_mac l=35.0n w=155.00n m=1
MM27 net122 clkb VSS VSS nch_mac l=35.0n w=270.0n m=1
MM14 net126 E net194 VSS nch_mac l=35.0n w=280.0n m=1
MM16 net130 net178 net186 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net141 D net186 VSS nch_mac l=35.0n w=155.00n m=1
MM20 net138 net196 net141 VSS nch_mac l=35.0n w=155.00n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=275.00n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=2
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq net186 net122 VSS nch_mac l=35.0n w=150.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=275.00n m=1
MM64 mq clkbb net165 VSS nch_mac l=35.0n w=150.0n m=1
MM65 net165 mq_x VSS VSS nch_mac l=35.0n w=150.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=195.00n m=1
MM24 net196 SE VSS VSS nch_mac l=35.0n w=100n m=1
MM2 net178 E VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net202 qf VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net186 SE net189 VSS nch_mac l=35.0n w=100n m=1
MM12 net189 SI VSS VSS nch_mac l=35.0n w=100n m=1
MM6 net194 net196 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM29 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=4
MM31 net202 net196 net130 VSS nch_mac l=35.0n w=155.00n m=1
MM10 qf_x clkbb net14 VDD pch_mac l=35.0n w=100n m=1
MM9 net14 qf VDD VDD pch_mac l=35.0n w=100n m=1
MM15 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM25 net22 SE net186 VDD pch_mac l=35.0n w=295.00n m=1
MM26 net202 E net22 VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=195.00n m=1
MM79 mq clkb net54 VDD pch_mac l=35.0n w=170.0n m=1
MM44 net61 clkbb VDD VDD pch_mac l=35.0n w=175.00n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net54 mq_x VDD VDD pch_mac l=35.0n w=170.0n m=1
MM45 mq net186 net61 VDD pch_mac l=35.0n w=170.0n m=1
MM17 net69 D net186 VDD pch_mac l=35.0n w=180.0n m=1
MM18 VDD net126 net69 VDD pch_mac l=35.0n w=180.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net126 net196 VDD VDD pch_mac l=35.0n w=100n m=1
MM13 net126 E VDD VDD pch_mac l=35.0n w=100n m=1
MM3 net178 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM1 net202 qf VDD VDD pch_mac l=35.0n w=170.0n m=1
MM30 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=4
MM21 net186 net196 net97 VDD pch_mac l=35.0n w=120.0n m=1
MM28 net97 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
MM34 net196 SE VDD VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt TIEHBWP35 Z VDD VSS
MM8 net10 net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt TIELBWP35 ZN VDD VSS
MM8 ZN net10 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net10 net10 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt TPND2D0BWP35 A1 A2 ZN VDD VSS
MM9 net14 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt TPND2D16BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=16
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=17
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt TPND2D1BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net10 VSS nch_mac l=35.0n w=280.0n m=1
MM9 net10 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt TPND2D2BWP35 A1 A2 ZN VDD VSS
MM4 ZN A1 net026 VSS nch_mac l=35.0n w=280.0n m=2
MM9 net026 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt TPND2D3BWP35 A1 A2 ZN VDD VSS
MM9 net43 A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 ZN A1 net43 VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt TPND2D4BWP35 A1 A2 ZN VDD VSS
MM9 net72 A2 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM4 ZN A1 net72 VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt TPND2D6BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=6
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=7
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt TPND2D8BWP35 A1 A2 ZN VDD VSS
MM30 ZN A1 net90 VSS nch_mac l=35.0n w=280.0n m=8
MM9 net90 A2 VSS VSS nch_mac l=35.0n w=280.0n m=9
MM39 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM2 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt TPND3D0BWP35 A1 A2 A3 ZN VDD VSS
MM0 net7 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 ZN A1 net15 VSS nch_mac l=35.0n w=140.0n m=1
MM9 net15 A2 net7 VSS nch_mac l=35.0n w=280.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt TPND3D16BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=17
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=17
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=16
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=16
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=16
.ends
.subckt TPND3D1BWP35 A1 A2 A3 ZN VDD VSS
MM9 net19 A2 net27 VSS nch_mac l=35.0n w=280.0n m=2
MM4 ZN A1 net19 VSS nch_mac l=35.0n w=280.0n m=1
MM0 net27 A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM1 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt TPND3D2BWP35 A1 A2 A3 ZN VDD VSS
MM15 net40 A2 net32 VSS nch_mac l=35.0n w=280.0n m=3
MM16 ZN A1 net40 VSS nch_mac l=35.0n w=280.0n m=2
MM17 net32 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt TPND3D3BWP35 A1 A2 A3 ZN VDD VSS
MM15 net96 A2 net100 VSS nch_mac l=35.0n w=280.0n m=4
MM17 net100 A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 ZN A1 net96 VSS nch_mac l=35.0n w=280.0n m=3
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt TPND3D4BWP35 A1 A2 A3 ZN VDD VSS
MM15 net96 A2 net100 VSS nch_mac l=35.0n w=280.0n m=5
MM17 net100 A3 VSS VSS nch_mac l=35.0n w=280.0n m=5
MM16 ZN A1 net96 VSS nch_mac l=35.0n w=280.0n m=4
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt TPND3D6BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=7
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=7
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=6
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=6
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=6
.ends
.subckt TPND3D8BWP35 A1 A2 A3 ZN VDD VSS
MM17 net65 A3 VSS VSS nch_mac l=35.0n w=280.0n m=9
MM15 net69 A2 net65 VSS nch_mac l=35.0n w=280.0n m=9
MM16 ZN A1 net69 VSS nch_mac l=35.0n w=280.0n m=8
MM9 ZN A1 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM14 ZN A2 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM3 ZN A3 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt TPNR2D0BWP35 A1 A2 ZN VDD VSS
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net21 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net21 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt TPNR2D16BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=16
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=17
.ends
.subckt TPNR2D1BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM16 ZN A1 net034 VDD pch_mac l=35.0n w=340.0n m=1
MM17 net034 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt TPNR2D2BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 ZN A1 net034 VDD pch_mac l=35.0n w=340.0n m=2
MM17 net034 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt TPNR2D3BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM16 ZN A1 net38 VDD pch_mac l=35.0n w=340.0n m=3
MM17 net38 A2 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt TPNR2D4BWP35 A1 A2 ZN VDD VSS
MM18 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM19 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 ZN A1 net38 VDD pch_mac l=35.0n w=340.0n m=4
MM17 net38 A2 VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt TPNR2D6BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=6
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=7
.ends
.subckt TPNR2D8BWP35 A1 A2 ZN VDD VSS
MM8 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM9 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM3 ZN A1 net9 VDD pch_mac l=35.0n w=340.0n m=8
MM7 net9 A2 VDD VDD pch_mac l=35.0n w=340.0n m=9
.ends
.subckt TPNR3D0BWP35 A1 A2 A3 ZN VDD VSS
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net18 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 ZN A1 net14 VDD pch_mac l=35.0n w=170.0n m=1
MM7 net14 A2 net18 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt TPNR3D16BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=16
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=17
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=16
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=17
.ends
.subckt TPNR3D1BWP35 A1 A2 A3 ZN VDD VSS
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 net099 A3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM10 ZN A1 net0103 VDD pch_mac l=35.0n w=340.0n m=1
MM11 net0103 A2 net099 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt TPNR3D2BWP35 A1 A2 A3 ZN VDD VSS
MM12 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net78 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM10 ZN A1 net82 VDD pch_mac l=35.0n w=340.0n m=2
MM11 net82 A2 net78 VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt TPNR3D3BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=4
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=3
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt TPNR3D4BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM7 net26 A2 net22 VDD pch_mac l=35.0n w=340.0n m=5
MM3 ZN A1 net26 VDD pch_mac l=35.0n w=340.0n m=4
MM0 net22 A3 VDD VDD pch_mac l=35.0n w=340.0n m=5
.ends
.subckt TPNR3D6BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=6
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=7
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=6
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=7
.ends
.subckt TPNR3D8BWP35 A1 A2 A3 ZN VDD VSS
MM9 ZN A2 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM8 ZN A3 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM35 ZN A1 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM7 net49 A2 net53 VDD pch_mac l=35.0n w=340.0n m=9
MM4 ZN A1 net49 VDD pch_mac l=35.0n w=340.0n m=8
MM5 net53 A3 VDD VDD pch_mac l=35.0n w=340.0n m=9
.ends
.subckt XNR2D0BWP35 A1 A2 ZN VDD VSS
MM8 net17 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net26 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN net16 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net46 net26 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net46 net17 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net26 A1 net16 VSS nch_mac l=35.0n w=140.0n m=1
MM7 ZN net16 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net17 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net26 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net46 net26 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net46 A1 net16 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net26 net17 net16 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XNR2D1BWP35 A1 A2 ZN VDD VSS
MM0 net6 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net34 net6 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM3 net34 net44 net45 VSS nch_mac l=35.0n w=205.00n m=1
MM17 net6 A1 net45 VSS nch_mac l=35.0n w=205.00n m=1
MM8 net44 A1 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM6 ZN net45 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net6 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net34 net6 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM4 net34 A1 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM16 net6 net44 net45 VDD pch_mac l=35.0n w=340.0n m=1
MM9 net44 A1 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM7 ZN net45 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XNR2D2BWP35 A1 A2 ZN VDD VSS
MM6 ZN net093 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM8 net17 A1 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM17 net26 A1 net093 VSS nch_mac l=35.0n w=205.00n m=1
MM3 net46 net17 net093 VSS nch_mac l=35.0n w=205.00n m=1
MM5 net46 net26 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM0 net26 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 ZN net093 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 net17 A1 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM16 net26 net17 net093 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net46 A1 net093 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net46 net26 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM2 net26 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XNR2D4BWP35 A1 A2 ZN VDD VSS
MM0 net6 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net45 net6 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net45 net44 net0117 VSS nch_mac l=35.0n w=280.0n m=2
MM17 net6 A1 net0117 VSS nch_mac l=35.0n w=280.0n m=2
MM8 net44 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 ZN net0117 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net6 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net45 net6 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 net45 A1 net0117 VDD pch_mac l=35.0n w=340.0n m=2
MM16 net6 net44 net0117 VDD pch_mac l=35.0n w=340.0n m=2
MM9 net44 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 ZN net0117 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt XNR2OPTND2BWP35 A1 A2 ZN VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM7 ZN A1 net3 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM4 ZN net15 net7 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM6 ZN net15 net3 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 ZN A1 net7 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt XNR2OPTND4BWP35 A1 A2 ZN VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM7 ZN A1 net3 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM4 ZN net15 net7 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 ZN net15 net3 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM5 ZN A1 net7 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt XNR2OPTND6BWP35 A1 A2 ZN VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
MM7 ZN A1 net3 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM4 ZN net15 net7 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM6 ZN net15 net3 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM5 ZN A1 net7 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt XNR2OPTND8BWP35 A1 A2 ZN VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM7 ZN A1 net3 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM4 ZN net15 net7 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM6 ZN net15 net3 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM5 ZN A1 net7 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt XNR3D0BWP35 A1 A2 A3 ZN VDD VSS
MM7 net71 net0127 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net87 net47 net69 VSS nch_mac l=35.0n w=140.0n m=1
MM13 net63 net47 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net58 net87 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net69 net63 net58 VSS nch_mac l=35.0n w=140.0n m=1
MM21 ZN net69 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net0127 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net0127 A2 net47 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net47 net35 net71 VSS nch_mac l=35.0n w=140.0n m=1
MM0 net87 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net35 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 net27 net0127 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net87 net63 net69 VDD pch_mac l=35.0n w=170.0n m=1
MM12 net63 net47 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM14 net14 net87 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net69 net47 net14 VDD pch_mac l=35.0n w=170.0n m=1
MM20 ZN net69 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net0127 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net0127 net35 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM2 net87 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net35 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net47 A2 net27 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XNR3D1BWP35 A1 A2 A3 ZN VDD VSS
MM33 net169 net93 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM34 net169 net153 net143 VSS nch_mac l=35.0n w=205.00n m=1
MM35 net161 net149 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM36 net161 net133 net135 VSS nch_mac l=35.0n w=280.0n m=1
MM37 net153 A2 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM38 net149 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM39 net93 A2 net143 VSS nch_mac l=35.0n w=205.00n m=1
MM40 net93 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net149 net143 net135 VSS nch_mac l=35.0n w=280.0n m=1
MM42 net133 net143 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM43 ZN net135 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM22 net161 net143 net135 VDD pch_mac l=35.0n w=265.00n m=1
MM23 net161 net149 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM24 net169 A2 net143 VDD pch_mac l=35.0n w=340.0n m=1
MM25 ZN net135 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net169 net93 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM27 net153 A2 VDD VDD pch_mac l=35.0n w=160.0n m=1
MM28 net149 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM29 net93 net153 net143 VDD pch_mac l=35.0n w=340.0n m=1
MM30 net93 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM31 net149 net133 net135 VDD pch_mac l=35.0n w=265.00n m=1
MM32 net133 net143 VDD VDD pch_mac l=35.0n w=315.00n m=1
.ends
.subckt XNR3D2BWP35 A1 A2 A3 ZN VDD VSS
MM5 net082 net179 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM7 net082 net191 net230 VSS nch_mac l=35.0n w=205.00n m=1
MM19 net195 net187 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM18 net195 net211 net206 VSS nch_mac l=35.0n w=280.0n m=1
MM8 net191 A2 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM0 net187 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net179 A2 net230 VSS nch_mac l=35.0n w=205.00n m=1
MM3 net179 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net187 net230 net206 VSS nch_mac l=35.0n w=280.0n m=1
MM13 net211 net230 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 ZN net206 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM14 net195 net230 net206 VDD pch_mac l=35.0n w=265.00n m=1
MM15 net195 net187 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM6 net082 A2 net230 VDD pch_mac l=35.0n w=340.0n m=1
MM20 ZN net206 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net082 net179 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM9 net191 A2 VDD VDD pch_mac l=35.0n w=160.0n m=1
MM2 net187 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net179 net191 net230 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net179 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM10 net187 net211 net206 VDD pch_mac l=35.0n w=265.00n m=1
MM12 net211 net230 VDD VDD pch_mac l=35.0n w=315.00n m=1
.ends
.subckt XNR3D4BWP35 A1 A2 A3 ZN VDD VSS
MM23 net129 net0160 net134 VDD pch_mac l=35.0n w=180.0n m=1
MM15 net129 net121 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 net097 A2 VDD VDD pch_mac l=35.0n w=160.0n m=1
MM2 net121 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 net0160 net097 net157 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net157 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM4 net0161 net157 VDD VDD pch_mac l=35.0n w=240.0n m=1
MM6 net0160 A2 net0161 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net101 net0160 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 ZN net134 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM10 net121 net101 net134 VDD pch_mac l=35.0n w=220.0n m=1
MM14 net129 net0160 net134 VDD pch_mac l=35.0n w=180.0n m=1
MM8 net097 A2 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM0 net121 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM17 net0160 A2 net157 VSS nch_mac l=35.0n w=205.00n m=1
MM3 net157 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM5 net0161 net157 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM7 net0160 net097 net0161 VSS nch_mac l=35.0n w=205.00n m=1
MM13 net101 net0160 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM21 ZN net134 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM11 net121 net0160 net134 VSS nch_mac l=35.0n w=220.0n m=1
MM18 net129 net101 net134 VSS nch_mac l=35.0n w=150.0n m=2
MM19 net129 net121 VSS VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt XNR4D0BWP35 A1 A2 A3 A4 ZN VDD VSS
MM43 ZN net77 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM41 net22 net0188 net77 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net118 net0166 net77 VSS nch_mac l=35.0n w=140.0n m=1
MM37 net0166 net0188 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net22 net118 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0173 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 net94 net42 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net57 net106 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net42 net0173 net0188 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net42 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net94 A4 net0188 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net118 A1 net57 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net106 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net106 net110 net118 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net110 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM42 ZN net77 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM39 net22 net0166 net77 VDD pch_mac l=35.0n w=170.0n m=1
MM38 net118 net0188 net77 VDD pch_mac l=35.0n w=170.0n m=1
MM36 net0166 net0188 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net22 net118 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net118 net110 net57 VDD pch_mac l=35.0n w=170.0n m=1
MM24 net94 net42 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0173 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 net42 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM23 net94 net0173 net0188 VDD pch_mac l=35.0n w=170.0n m=1
MM22 net42 A4 net0188 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net57 net106 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net106 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net106 A1 net118 VDD pch_mac l=35.0n w=170.0n m=1
MM9 net110 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XNR4D1BWP35 A1 A2 A3 A4 ZN VDD VSS
MM3 net24 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net76 A1 net72 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net72 net24 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net20 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net24 net20 net76 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net88 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net36 A4 net0128 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net36 net88 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net88 net0189 net0128 VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0189 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net48 net76 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net0197 net0128 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 net76 net0197 net59 VSS nch_mac l=35.0n w=140.0n m=1
MM41 net48 net0128 net59 VSS nch_mac l=35.0n w=140.0n m=1
MM43 ZN net59 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net24 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net72 net24 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net76 net20 net72 VDD pch_mac l=35.0n w=170.0n m=1
MM9 net20 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net24 A1 net76 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net88 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net36 net0189 net0128 VDD pch_mac l=35.0n w=170.0n m=1
MM24 net36 net88 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net88 A4 net0128 VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0189 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net48 net76 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net0197 net0128 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM38 net76 net0128 net59 VDD pch_mac l=35.0n w=170.0n m=1
MM39 net48 net0197 net59 VDD pch_mac l=35.0n w=170.0n m=1
MM42 ZN net59 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XNR4D2BWP35 A1 A2 A3 A4 ZN VDD VSS
MM4 net16 net124 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net16 A1 net71 VSS nch_mac l=35.0n w=140.0n m=1
MM43 ZN net91 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM41 net36 net0187 net91 VSS nch_mac l=35.0n w=140.0n m=1
MM40 net71 net107 net91 VSS nch_mac l=35.0n w=140.0n m=1
MM37 net107 net0187 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net36 net71 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0180 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net116 net0180 net0187 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net48 net116 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net48 A4 net0187 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net116 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net124 net60 net71 VSS nch_mac l=35.0n w=140.0n m=1
MM8 net60 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net124 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net16 net60 net71 VDD pch_mac l=35.0n w=170.0n m=1
MM0 net16 net124 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM42 ZN net91 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM39 net36 net107 net91 VDD pch_mac l=35.0n w=170.0n m=1
MM38 net71 net0187 net91 VDD pch_mac l=35.0n w=170.0n m=1
MM36 net107 net0187 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net36 net71 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0180 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net116 A4 net0187 VDD pch_mac l=35.0n w=170.0n m=1
MM24 net48 net116 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM23 net48 net0180 net0187 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net116 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net124 A1 net71 VDD pch_mac l=35.0n w=170.0n m=1
MM9 net60 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net124 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XNR4D4BWP35 A1 A2 A3 A4 ZN VDD VSS
MM3 net8 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net12 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM30 net16 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net84 A4 net31 VSS nch_mac l=35.0n w=140.0n m=1
MM29 net84 net16 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net16 net0176 net31 VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0176 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net36 net67 VSS VSS nch_mac l=35.0n w=200n m=2
MM37 net100 net31 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 net67 net100 net47 VSS nch_mac l=35.0n w=140.0n m=1
MM41 net36 net31 net47 VSS nch_mac l=35.0n w=140.0n m=1
MM43 ZN net47 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net60 A1 net67 VSS nch_mac l=35.0n w=140.0n m=1
MM4 net60 net8 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net8 net12 net67 VSS nch_mac l=35.0n w=140.0n m=1
MM1 net8 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net12 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM25 net16 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net84 net0176 net31 VDD pch_mac l=35.0n w=170.0n m=1
MM24 net84 net16 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net16 A4 net31 VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0176 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net36 net67 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM36 net100 net31 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM38 net67 net31 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM39 net36 net100 net47 VDD pch_mac l=35.0n w=170.0n m=1
MM42 ZN net47 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM0 net60 net8 VDD VDD pch_mac l=35.0n w=270.0n m=1
MM2 net60 net12 net67 VDD pch_mac l=35.0n w=170.0n m=1
MM16 net8 A1 net67 VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XOR2D0BWP35 A1 A2 Z VDD VSS
MM17 net10 net36 net13 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net10 A1 net14 VSS nch_mac l=35.0n w=140.0n m=1
MM5 net14 net13 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM6 Z net10 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net13 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM8 net36 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net10 A1 net13 VDD pch_mac l=35.0n w=170.0n m=1
MM4 net10 net36 net14 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net14 net13 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net13 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM9 net36 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM7 Z net10 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XOR2D1BWP35 A1 A2 Z VDD VSS
MM8 net24 A1 VSS VSS nch_mac l=35.0n w=245.00n m=1
MM0 net49 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM6 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net42 net49 VSS VSS nch_mac l=35.0n w=245.00n m=1
MM17 net46 net24 net49 VSS nch_mac l=35.0n w=205.00n m=1
MM3 net46 A1 net42 VSS nch_mac l=35.0n w=205.00n m=1
MM7 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net24 A1 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM2 net49 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net42 net49 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM16 net46 A1 net49 VDD pch_mac l=35.0n w=340.0n m=1
MM4 net46 net24 net42 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XOR2D2BWP35 A1 A2 Z VDD VSS
MM3 net10 A1 net14 VSS nch_mac l=35.0n w=205.00n m=1
MM17 net10 net36 net13 VSS nch_mac l=35.0n w=205.00n m=1
MM5 net14 net13 VSS VSS nch_mac l=35.0n w=245.00n m=1
MM6 Z net10 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net13 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net36 A1 VSS VSS nch_mac l=35.0n w=245.00n m=1
MM16 net10 A1 net13 VDD pch_mac l=35.0n w=340.0n m=1
MM1 net14 net13 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM2 net13 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net36 A1 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM7 Z net10 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM4 net10 net36 net14 VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XOR2D4BWP35 A1 A2 Z VDD VSS
MM8 net24 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net49 A2 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM6 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 net18 net49 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net46 net24 net49 VSS nch_mac l=35.0n w=280.0n m=2
MM3 net46 A1 net18 VSS nch_mac l=35.0n w=280.0n m=2
MM7 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM9 net24 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net49 A2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 net18 net49 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net46 A1 net49 VDD pch_mac l=35.0n w=340.0n m=2
MM4 net46 net24 net18 VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt XOR2OPTND2BWP35 A1 A2 Z VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=1 nf=1
MM7 Z net15 net3 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM4 Z A1 net7 VDD pch_mac l=35n w=340.0n m=2 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=1 nf=1
MM6 Z A1 net3 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM5 Z net15 net7 VSS nch_mac l=35n w=280.0n m=2 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
.ends
.subckt XOR2OPTND4BWP35 A1 A2 Z VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=2 nf=1
MM7 Z net15 net3 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM4 Z A1 net7 VDD pch_mac l=35n w=340.0n m=4 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=2 nf=1
MM6 Z A1 net3 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM5 Z net15 net7 VSS nch_mac l=35n w=280.0n m=4 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
.ends
.subckt XOR2OPTND6BWP35 A1 A2 Z VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=3 nf=1
MM7 Z net15 net3 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM4 Z A1 net7 VDD pch_mac l=35n w=340.0n m=6 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=6 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=3 nf=1
MM6 Z A1 net3 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM5 Z net15 net7 VSS nch_mac l=35n w=280.0n m=6 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=6 nf=1
.ends
.subckt XOR2OPTND8BWP35 A1 A2 Z VDD VSS
MM9 net15 A1 VDD VDD pch_mac l=35n w=340.0n m=4 nf=1
MM7 Z net15 net3 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM4 Z A1 net7 VDD pch_mac l=35n w=340.0n m=8 nf=1
MM3 net7 net3 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM0 net3 A2 VDD VDD pch_mac l=35n w=340.0n m=8 nf=1
MM8 net15 A1 VSS VSS nch_mac l=35n w=280.0n m=4 nf=1
MM6 Z A1 net3 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM5 Z net15 net7 VSS nch_mac l=35n w=280.0n m=8 nf=1
MM2 net7 net3 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
MM1 net3 A2 VSS VSS nch_mac l=35n w=280.0n m=8 nf=1
.ends
.subckt XOR3D0BWP35 A1 A2 A3 Z VDD VSS
MM8 net55 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM0 net11 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 net63 A2 net18 VSS nch_mac l=35.0n w=140.0n m=1
MM17 net63 net55 net67 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net67 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM21 Z net46 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net46 net39 net34 VSS nch_mac l=35.0n w=140.0n m=1
MM18 net34 net11 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM13 net39 net63 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM11 net11 net63 net46 VSS nch_mac l=35.0n w=140.0n m=1
MM7 net18 net67 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM4 net63 net55 net54 VDD pch_mac l=35.0n w=170.0n m=1
MM9 net55 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM2 net11 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net63 A2 net67 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net67 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM20 Z net46 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM15 net46 net63 net78 VDD pch_mac l=35.0n w=170.0n m=1
MM14 net78 net11 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM12 net39 net63 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM10 net11 net39 net46 VDD pch_mac l=35.0n w=170.0n m=1
MM6 net54 net67 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XOR3D1BWP35 A1 A2 A3 Z VDD VSS
MM26 net150 A2 net088 VSS nch_mac l=35.0n w=275.00n m=1
MM30 net229 net214 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net214 net150 net209 VSS nch_mac l=35.0n w=280.0n m=1
MM24 net150 net210 net178 VSS nch_mac l=35.0n w=275.00n m=1
MM22 net210 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM23 net214 A3 VSS VSS nch_mac l=35n w=280.0n m=1
MM29 net218 net150 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM25 net178 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM31 net209 net218 net229 VSS nch_mac l=35.0n w=280.0n m=1
MM27 net088 net178 VSS VSS nch_mac l=35.0n w=275.00n m=1
MM32 Z net209 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM37 net150 net210 net088 VDD pch_mac l=35.0n w=325.00n m=1
MM38 net088 net178 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 net214 net218 net209 VDD pch_mac l=35.0n w=265.00n m=1
MM41 net229 net214 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM43 Z net209 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 net209 net150 net229 VDD pch_mac l=35.0n w=265.00n m=1
MM36 net178 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM35 net150 A2 net178 VDD pch_mac l=35.0n w=325.00n m=1
MM40 net218 net150 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM33 net210 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net214 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XOR3D2BWP35 A1 A2 A3 Z VDD VSS
MM21 Z net18 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM13 net11 net63 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net27 net63 net18 VSS nch_mac l=35.0n w=280.0n m=1
MM3 net19 A1 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net63 net31 net19 VSS nch_mac l=35.0n w=275.00n m=1
MM0 net27 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net31 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM18 net87 net11 net18 VSS nch_mac l=35.0n w=280.0n m=1
MM19 net87 net27 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM7 net0167 A2 net63 VSS nch_mac l=35.0n w=275.00n m=1
MM5 net0167 net19 VSS VSS nch_mac l=35.0n w=275.00n m=1
MM12 net11 net63 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM10 net27 net11 net18 VDD pch_mac l=35.0n w=265.00n m=1
MM1 net19 A1 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net63 A2 net19 VDD pch_mac l=35.0n w=325.00n m=1
MM2 net27 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net31 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 net0167 net19 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 Z net18 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net0167 net31 net63 VDD pch_mac l=35.0n w=325.00n m=1
MM15 net87 net27 VDD VDD pch_mac l=35.0n w=315.00n m=1
MM14 net87 net63 net18 VDD pch_mac l=35.0n w=265.00n m=1
.ends
.subckt XOR3D4BWP35 A1 A2 A3 Z VDD VSS
MM43 Z net159 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM38 net134 net142 VDD VDD pch_mac l=35.0n w=245.00n m=1
MM35 net98 A2 net142 VDD pch_mac l=35.0n w=340.0n m=1
MM40 net94 net98 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM33 net154 A2 VDD VDD pch_mac l=35.0n w=160.0n m=1
MM34 net150 A3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM37 net98 net154 net134 VDD pch_mac l=35.0n w=340.0n m=1
MM41 net135 net150 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM39 net150 net94 net159 VDD pch_mac l=35.0n w=340.0n m=2
MM42 net159 net98 net135 VDD pch_mac l=35.0n w=340.0n m=2
MM36 net142 A1 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM23 net150 A3 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM30 net135 net150 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM24 net98 net154 net142 VSS nch_mac l=35.0n w=205.00n m=1
MM27 net134 net142 VSS VSS nch_mac l=35.0n w=205.00n m=1
MM29 net94 net98 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM26 net98 A2 net134 VSS nch_mac l=35.0n w=205.00n m=1
MM25 net142 A1 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM32 Z net159 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM22 net154 A2 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM31 net159 net94 net135 VSS nch_mac l=35.0n w=280.0n m=2
MM28 net150 net98 net159 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt XOR4D0BWP35 A1 A2 A3 A4 Z VDD VSS
MM8 net68 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net12 net68 net104 VSS nch_mac l=35.0n w=140.0n m=1
MM3 net12 A2 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM7 net104 A1 net80 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net40 A4 net35 VSS nch_mac l=35.0n w=140.0n m=1
MM30 net28 A3 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM27 net28 net0182 net35 VSS nch_mac l=35.0n w=140.0n m=1
MM33 net80 net12 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM29 net40 net28 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM31 net0182 A4 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net108 net104 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM37 net112 net35 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM40 net104 net35 net59 VSS nch_mac l=35.0n w=140.0n m=1
MM41 net108 net112 net59 VSS nch_mac l=35.0n w=140.0n m=1
MM43 Z net59 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM9 net68 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net12 A1 net104 VDD pch_mac l=35.0n w=170.0n m=1
MM1 net12 A2 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM6 net80 net12 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net28 A4 net35 VDD pch_mac l=35.0n w=170.0n m=1
MM23 net40 net0182 net35 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net28 A3 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net0182 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM24 net40 net28 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net104 net68 net80 VDD pch_mac l=35.0n w=170.0n m=1
MM34 net108 net104 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM36 net112 net35 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM38 net104 net112 net59 VDD pch_mac l=35.0n w=170.0n m=1
MM39 net108 net35 net59 VDD pch_mac l=35.0n w=170.0n m=1
MM42 Z net59 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt XOR4D1BWP35 A1 A2 A3 A4 Z VDD VSS
MM43 Z net79 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM41 net84 net95 net79 VSS nch_mac l=35.0n w=155.00n m=1
MM40 net120 net80 net79 VSS nch_mac l=35.0n w=155.00n m=1
MM37 net95 net80 VSS VSS nch_mac l=35.0n w=200n m=1
MM35 net84 net120 VSS VSS nch_mac l=35.0n w=200n m=1
MM31 net0174 A4 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM27 net104 net0174 net80 VSS nch_mac l=35.0n w=150.0n m=1
MM29 net36 net104 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM28 net36 A4 net80 VSS nch_mac l=35.0n w=150.0n m=1
MM30 net104 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 net64 net112 net120 VSS nch_mac l=35.0n w=275.00n m=1
MM8 net112 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM33 net123 net64 VSS VSS nch_mac l=35.0n w=275.00n m=1
MM7 net120 A1 net123 VSS nch_mac l=35.0n w=275.00n m=1
MM3 net64 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM42 Z net79 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM39 net84 net80 net79 VDD pch_mac l=35.0n w=165.00n m=1
MM38 net120 net95 net79 VDD pch_mac l=35.0n w=165.00n m=1
MM36 net95 net80 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM34 net84 net120 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM26 net0174 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net104 A4 net80 VDD pch_mac l=35.0n w=165.00n m=1
MM24 net36 net104 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net36 net0174 net80 VDD pch_mac l=35.0n w=165.00n m=1
MM25 net104 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 net64 A1 net120 VDD pch_mac l=35.0n w=260.0n m=1
MM9 net112 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM32 net120 net112 net123 VDD pch_mac l=35.0n w=260.0n m=1
MM6 net123 net64 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 net64 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt XOR4D2BWP35 A1 A2 A3 A4 Z VDD VSS
MM3 net8 A2 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net12 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM17 net8 net12 net19 VSS nch_mac l=35.0n w=275.00n m=1
MM30 net80 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM28 net88 A4 net0120 VSS nch_mac l=35.0n w=150.0n m=1
MM29 net88 net80 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM27 net80 net0181 net0120 VSS nch_mac l=35.0n w=150.0n m=1
MM31 net0181 A4 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM35 net100 net19 VSS VSS nch_mac l=35.0n w=200n m=1
MM37 net35 net0120 VSS VSS nch_mac l=35.0n w=200n m=1
MM40 net19 net0120 net51 VSS nch_mac l=35.0n w=160.0n m=1
MM41 net100 net35 net51 VSS nch_mac l=35.0n w=160.0n m=1
MM43 Z net51 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM5 net64 A1 net19 VSS nch_mac l=35.0n w=275.00n m=1
MM4 net64 net8 VSS VSS nch_mac l=35.0n w=275.00n m=1
MM1 net8 A2 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net12 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM16 net8 A1 net19 VDD pch_mac l=35.0n w=260.0n m=1
MM25 net80 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net88 net0181 net0120 VDD pch_mac l=35.0n w=165.00n m=1
MM24 net88 net80 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM22 net80 A4 net0120 VDD pch_mac l=35.0n w=165.00n m=1
MM26 net0181 A4 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net100 net19 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM36 net35 net0120 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM38 net19 net35 net51 VDD pch_mac l=35.0n w=165.00n m=1
MM39 net100 net0120 net51 VDD pch_mac l=35.0n w=165.00n m=1
MM42 Z net51 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM0 net64 net8 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM2 net64 net12 net19 VDD pch_mac l=35.0n w=260.0n m=1
.ends
.subckt XOR4D4BWP35 A1 A2 A3 A4 Z VDD VSS
MM17 net64 net120 net71 VSS nch_mac l=35.0n w=280.0n m=1
MM4 net16 net64 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 net16 A1 net71 VSS nch_mac l=35.0n w=280.0n m=1
MM43 Z net91 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM41 net36 net32 net91 VSS nch_mac l=35.0n w=150.0n m=1
MM40 net71 net107 net91 VSS nch_mac l=35.0n w=150.0n m=1
MM37 net32 net107 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM35 net36 net71 VSS VSS nch_mac l=35.0n w=200n m=2
MM31 net0185 A4 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM27 net116 net0185 net107 VSS nch_mac l=35.0n w=150.0n m=1
MM29 net48 net116 VSS VSS nch_mac l=35.0n w=150.0n m=1
MM28 net48 A4 net107 VSS nch_mac l=35.0n w=150.0n m=1
MM30 net116 A3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM8 net120 A1 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM3 net64 A2 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 net64 A1 net71 VDD pch_mac l=35.0n w=245.00n m=1
MM2 net16 net120 net71 VDD pch_mac l=35.0n w=245.00n m=1
MM0 net16 net64 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM42 Z net91 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM39 net36 net107 net91 VDD pch_mac l=35.0n w=155.00n m=1
MM38 net71 net32 net91 VDD pch_mac l=35.0n w=155.00n m=1
MM36 net32 net107 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM34 net36 net71 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM26 net0185 A4 VDD VDD pch_mac l=35.0n w=150.0n m=1
MM22 net116 A4 net107 VDD pch_mac l=35.0n w=165.00n m=1
MM24 net48 net116 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM23 net48 net0185 net107 VDD pch_mac l=35.0n w=165.00n m=1
MM25 net116 A3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 net120 A1 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM1 net64 A2 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt DFCNOPTMAD8BWP35 D CP CDN Q QN VDD VSS
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPINV_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_VDPOUT_T2S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=1
XMN_VDPINV_T1S1 VSS net0141 net0139 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S2 net0138 CP_minus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CDN net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_VDPOUT_T2S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=3
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt DFCNQOPTMAD8BWP35 D CP CDN Q VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=5
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1B CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1A CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=2
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S2 net0138 CP_minus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CDN net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=3
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt DFKCNOPTMAD8BWP35 D CP CN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0125 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_VDPINV_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CPNN net0222 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=6
XMN_DPIN_T1S3 net0135 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=5
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=5
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_VDPOUT_T2S1 QN net0125 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 VSS net0158 net0125 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt DFKCNQOPTMAD8BWP35 D CP CN Q VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CPNN net0222 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=6
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPIN_T1S3 net0135 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=5
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=155.00n m=1
.ends
.subckt DFKSNOPTMAD8BWP35 D CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0166 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=290.0n m=1
XMP_DPIN_T1S3 net0199 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_VDPINV_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CPNN net0255 VDD pch_mac l=35.0n w=290.0n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=270.0n m=7
XMN_VDPOUT_T2S1 QN net0166 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=200n m=4
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=175.00n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T2S1_1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=4
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_CKIN_T2S1_0 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=175.00n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 VSS net0187 net0166 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt DFMOPTMAD8BWP35 DA DB SA CP Q QN VDD VSS
XMP_VDPINV_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=8
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_VDPOUT_T2S1 QN net0178 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CPNN net0275 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S3 net0236 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=6
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=5
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPOUT_T2S1 QN net0178 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S3 net0137 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=6
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 VSS net0138 net0178 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt DFMQOPTMAD8BWP35 DA DB SA CP Q VDD VSS
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CPNN net0275 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S3 net0236 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=6
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=5
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S3 net0137 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=6
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt DFOPTMAD8BWP35 D CP Q QN VDD VSS
XMP_DPIN_T1S1_0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 QN net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=280.0n m=1
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CPNN net200 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1_1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMN_VDPOUT_T2S1 QN net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=5
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPIN_T1S2 net0123 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=5
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 VSS net0167 net0176 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt DFQOPTMAD8BWP35 D CP Q VDD VSS
XMP_DPIN_T1S1_0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=1
MM0 CPNN CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CPNN net200 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1_1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=5
MM1 CPNN CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S2 net0123 CPNN VSS VSS nch_mac l=35.0n w=210.0n m=5
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt DFSNOPTMAD8BWP35 D CP SDN Q QN VDD VSS
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0212 net0130 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T1S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T1S1A CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_VDPINV_T1S1 net0113 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_VDPOUT_T2S1 QN net0113 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T1S2 net0167 net0113 net0212 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=290.0n m=5
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_CTL_T1S1B CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL SDN net0153 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2B net0151 net0113 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=130.0n m=1
XMN_VDPOUT_T2S1 QN net0113 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_VDPINV_T1S1 VSS net0141 net0113 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S2A net0151 net0130 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T1S2 net0153 CP_minus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt DFSNQOPTMAD8BWP35 D CP SDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
MM0 net090 D net0256 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CTL_T1S1A CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=4
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=330.0n m=5
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_CTL_T1S1B CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=115.00n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL SDN net0153 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=115.00n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T1S2 net0153 CP_minus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNOPTMAD12BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=2
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=10
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=3
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=2
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=12
.ends
.subckt SDFCNOPTMAD4BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=2
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNOPTMAD8BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=5
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=3
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt SDFCNOPTMBD12BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_VDPOUT_T2S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=9
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPINV_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=2
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=7
XMN_VDPOUT_T2S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_VDPINV_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=215.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=9
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=215.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=6
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=12
.ends
.subckt SDFCNOPTMBD4BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=2
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPINV_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_VDPOUT_T2S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPINV_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNOPTMBD8BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_VDPOUT_T2S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPINV_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_VDPOUT_T2S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_VDPINV_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=4
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt SDFCNOPTSADD12BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=2
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=10
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=3
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=2
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=12
.ends
.subckt SDFCNOPTSADD4BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=2
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNOPTSADD8BWP35 SI D SE CP CDN Q QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_CDNINV_T1S1 VDD CDN net0133 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S3 net0248 net0133 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_LH2FB_T1S2 net0241 net0167 net0248 VDD pch_mac l=35.0n w=185.00n m=1
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_KCNIN_T1S1 net0155 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH1FB_T1S1 net0268 CP_minus_mfb net0155 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0268 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0268 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net0155 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=320.0n m=5
XMP_SPIN_T1S1 net0155 SEN net0252 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0247 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0252 CP_plus net0283 VDD pch_mac l=35.0n w=100n m=1
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net0155 D net0247 VDD pch_mac l=35.0n w=340.0n m=3
XMP_SPIN_T1S3 net0283 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_CDNINV_T1S1 VSS CDN net0133 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T1S2B net0177 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_LH2FB_T1S2A net0177 net0133 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPINV_T2S2 net0137 net0155 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0204 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0195 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2 net0180 CDN net0156 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T1S2 net0195 SEN net0204 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SPIN_T1S3 net0164 SI net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0179 CP_minus net0164 VSS nch_mac l=35.0n w=100n m=1
XMN_LH2FB_T1S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=155.00n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_LH1FB_T1S1 net0180 CP_plus net0155 VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S2 net0163 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S3 net0156 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net0155 D net0163 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net0155 SE net0179 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0144 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt SDFCNQNOPTMAD12BWP35 SI D SE CP CDN QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=190.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=190.0n m=2
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=330.0n m=9
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net090 D net0121 VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=215.00n m=2
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=215.00n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM1 net090 D net0144 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQNOPTMAD4BWP35 SI D SE CP CDN QN VDD VSS
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=2
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=130.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQNOPTMAD8BWP35 SI D SE CP CDN QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=330.0n m=5
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net090 D net0121 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=115.00n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQNOPTSADD12BWP35 SI D SE CP CDN QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
MM0 net090 D net0121 VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=190.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=190.0n m=2
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=330.0n m=9
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
MM1 net090 D net0144 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=215.00n m=2
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=9
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=215.00n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQNOPTSADD4BWP35 SI D SE CP CDN QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=2
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQNOPTSADD8BWP35 SI D SE CP CDN QN VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
MM0 net090 D net0121 VDD pch_mac l=35.0n w=270.0n m=2
XMP_SPIN_T1S2 net0229 CP_plus net0240 VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T2S1 net0241 CP_plus net0139 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_SPIN_T1S3 net0240 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_LH2FB_T1S1A net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net0234 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0234 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0234 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0167 net0241 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=330.0n m=5
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1B net0167 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net090 D net0121 VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S1 net090 SEN net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0121 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH2FB_T2S2 VSS net0167 net0177 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0142 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0149 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0140 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S2 net0140 SEN net0149 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0177 CP_minus net0139 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH1FB_T1S2 net0142 CDN net0134 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0167 CDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0139 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net090 D net0144 VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S3 net0134 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S4 net0129 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0144 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0145 SI net0129 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_SPIN_T1S2 net0152 CP_minus net0145 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFCNQOPTMAD12BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=8
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=2
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=5
MM1 net090 D net0196 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=215.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=215.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=12
.ends
.subckt SDFCNQOPTMAD4BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=140.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=2
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNQOPTMAD8BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=3
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=175.00n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt SDFCNQOPTSADD12BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=8
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=2
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=215.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=215.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM1 net090 D net0196 VSS nch_mac l=35.0n w=210.0n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=12
.ends
.subckt SDFCNQOPTSADD4BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=140.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=2
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=140.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=140.0n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=175.00n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=4
.ends
.subckt SDFCNQOPTSADD8BWP35 SI D SE CP CDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_CKIN_T1S1_1 CP_minus CP VDD VDD pch_mac l=35.0n w=260.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0242 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S2 net0235 CP_plus net0236 VDD pch_mac l=35.0n w=100n m=1
XMP_SPIN_T1S3 net0236 SI VDD VDD pch_mac l=35.0n w=100n m=1
XMP_KCNIN_T1S1 net090 CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=185.00n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=265.00n m=1
MM0 net090 D net0324 VDD pch_mac l=35.0n w=270.0n m=2
XMP_LH2FB_T2S2B net0167 net0139 VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_DPCK_T3S1 net0242 CP_minus net0141 VDD pch_mac l=35.0n w=335.00n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2A net0224 CDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S2B net0224 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0139 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2A net0167 CDN VDD VDD pch_mac l=35.0n w=185.00n m=1
XMP_SPIN_T1S1 net090 SEN net0235 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL CDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T1S1_0 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0324 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_DPIN_T1S1 net090 D net0324 VDD pch_mac l=35.0n w=340.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=185.00n m=1
XMN_LH2FB_T1S1 net0139 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T1S3 net0164 CDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0153 VSS nch_mac l=35.0n w=260.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=120.0n m=1
XMN_SPIN_T1S2 net0126 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_CTL_T1S2 net0153 SEN net0164 VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S2 VSS net0137 net0143 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=145.00n m=1
XMN_DPCK_T3S1 net0143 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0136 CDN net0140 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0151 CDN net0147 VSS nch_mac l=35.0n w=145.00n m=1
XMN_LH2FB_T2S3 net0147 net0139 VSS VSS nch_mac l=35.0n w=145.00n m=1
XMN_SPIN_T1S3 net0148 SI net0125 VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0196 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_LH1FB_T1S3 net0140 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S1 net090 D net0196 VSS nch_mac l=35.0n w=280.0n m=3
XMN_SPIN_T1S1 net090 SE net0126 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S4 net0125 CDN VSS VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=210.0n m=2
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
.ends
.subckt SDFKCNOPTMAD12BWP35 SI D SE CP CN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_KCNIN_T1S1 net92 CN net0236 VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2 net0223 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=10
XMP_SPIN_T1S3 net0247 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0126 CP_plus net0247 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0126 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0219 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0219 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0223 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S1 net92 D net0236 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S3 net0171 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_CTL_T1S2 net0149 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0147 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 VSS net0167 net0176 VSS nch_mac l=35.0n w=280.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0149 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_DPIN_T1S1 net92 D net0160 VSS nch_mac l=35.0n w=280.0n m=7
XMN_DPIN_T1S2 net0160 CN net0171 VSS nch_mac l=35.0n w=280.0n m=9
XMN_SPIN_T1S3 net0156 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0155 CP_minus net0156 VSS nch_mac l=35.0n w=100n m=1
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0147 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0139 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0139 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_SPIN_T1S1 net92 SE net0155 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCNOPTMAD4BWP35 SI D SE CP CN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_KCNIN_T1S1 net92 CN net0236 VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0223 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0247 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0126 CP_plus net0247 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0126 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0219 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0219 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S2 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0223 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0236 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S3 net0171 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T1S2 net0149 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0147 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 VSS net0167 net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0149 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0160 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0160 CN net0171 VSS nch_mac l=35.0n w=280.0n m=3
XMN_SPIN_T1S3 net0156 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0155 CP_minus net0156 VSS nch_mac l=35.0n w=100n m=1
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0147 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0139 net0176 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0139 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net92 SE net0155 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCNOPTMAD8BWP35 SI D SE CP CN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_KCNIN_T1S1 net92 CN net0236 VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net0223 net0240 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=5
XMP_SPIN_T1S3 net0247 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0126 CP_plus net0247 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0126 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH2FB_T2S2 net0219 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0219 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0223 VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S1 net92 D net0236 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S3 net0171 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_CTL_T1S2 net0149 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_LH1FB_T1S2 net0147 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 VSS net0167 net0176 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T1S1 CTRL CP_minus net0149 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPIN_T1S1 net92 D net0160 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S2 net0160 CN net0171 VSS nch_mac l=35.0n w=280.0n m=6
XMN_SPIN_T1S3 net0156 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0155 CP_minus net0156 VSS nch_mac l=35.0n w=100n m=1
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0147 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0139 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0139 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net92 SE net0155 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKCNOPTMBD12BWP35 SI D SE CP CN Q QN VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_VDPOUT_T2S1 QN net0125 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_VDPINV_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=10
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=6
XMN_VDPINV_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=10
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPOUT_T2S1 QN net0125 VSS VSS nch_mac l=35.0n w=280.0n m=9
.ends
.subckt SDFKCNOPTMBD4BWP35 SI D SE CP CN Q QN VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_VDPOUT_T2S1 QN net0125 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_VDPINV_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=3
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPOUT_T2S1 QN net0125 VSS VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFKCNOPTMBD8BWP35 SI D SE CP CN Q QN VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_VDPOUT_T2S1 QN net0125 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_VDPINV_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=4
XMN_VDPINV_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=4
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPOUT_T2S1 QN net0125 VSS VSS nch_mac l=35.0n w=280.0n m=6
.ends
.subckt SDFKCNQOPTMAD12BWP35 SI D SE CP CN Q VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=10
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFKCNQOPTMAD4BWP35 SI D SE CP CN Q VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=3
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=195.00n m=1
.ends
.subckt SDFKCNQOPTMAD8BWP35 SI D SE CP CN Q VDD VSS
XMP_KCNIN_T1S1 net92 CN net0199 VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0222 net0141 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0249 CP_minus net0158 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0141 net0249 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0221 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0220 CP_plus net0221 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0220 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0237 net0125 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0158 CP_plus net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0141 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0125 net0158 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0222 VDD pch_mac l=35.0n w=275.00n m=1
XMP_DPOUT_T4S1 Q net0158 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMN_DPIN_T1S3 net0135 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_CTL_T1S1 CTRL CP_minus net0126 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0126 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0166 net0141 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0141 net0162 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S2 net0123 CN net0135 VSS nch_mac l=35.0n w=280.0n m=4
XMN_SPIN_T1S3 net0144 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0137 CP_minus net0144 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0137 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0162 CP_plus net0158 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0158 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0166 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0149 net0125 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0158 CP_minus net0149 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0141 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0125 net0158 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFKSNOPTMAD12BWP35 SI D SE CP SN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0168 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPIN_T1S2 net0276 SNB net0268 VDD pch_mac l=35.0n w=340.0n m=11
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0237 net0144 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPIN_T1S3 net0268 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_DPCK_T2S1 net0164 CP_minus net0144 VDD pch_mac l=35.0n w=325.00n m=10
XMP_SPIN_T1S3 net0280 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0269 CP_plus net0280 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_VDPINV_T1S1 net0168 net0164 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0248 net0168 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0164 CP_plus net0248 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0144 net92 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0164 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net92 D net0276 VDD pch_mac l=35.0n w=340.0n m=6
XMP_SPIN_T1S1 net92 SEN net0269 VDD pch_mac l=35.0n w=120.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0168 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_CTL_T1S2 net0148 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0148 VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_LH1FB_T1S2 net0169 net0144 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPOUT_T3S1 QN net0164 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0192 VSS nch_mac l=35.0n w=280.0n m=6
XMN_KSNIN_T1S1 net92 SNB net0192 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0192 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0185 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0184 CP_minus net0185 VSS nch_mac l=35.0n w=100n m=1
XMN_VDPINV_T1S1 VSS net0164 net0168 VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T2S1 net0164 CP_plus net0144 VSS nch_mac l=35.0n w=280.0n m=10
XMN_LH1FB_T1S1 net92 CP_plus net0169 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0152 net0168 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0164 CP_minus net0152 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0144 net92 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_SPIN_T1S1 net92 SE net0184 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKSNOPTMAD4BWP35 SI D SE CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0168 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPIN_T1S2 net0276 SNB net0268 VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0237 net0144 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPIN_T1S3 net0268 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPCK_T2S1 net0164 CP_minus net0144 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0280 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0269 CP_plus net0280 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPINV_T1S1 net0168 net0164 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0248 net0168 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0164 CP_plus net0248 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S2 net0144 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0237 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0164 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net92 D net0276 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S1 net92 SEN net0269 VDD pch_mac l=35.0n w=120.0n m=1
XMN_VDPOUT_T2S1 Q net0168 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0148 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0148 VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_LH1FB_T1S2 net0169 net0144 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPOUT_T3S1 QN net0164 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0192 VSS nch_mac l=35.0n w=280.0n m=2
XMN_KSNIN_T1S1 net92 SNB net0192 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0192 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0185 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0184 CP_minus net0185 VSS nch_mac l=35.0n w=100n m=1
XMN_VDPINV_T1S1 VSS net0164 net0168 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0164 CP_plus net0144 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net92 CP_plus net0169 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0152 net0168 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0164 CP_minus net0152 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0144 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S1 net92 SE net0184 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKSNOPTMAD8BWP35 SI D SE CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 Q net0168 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPIN_T1S2 net0276 SNB net0268 VDD pch_mac l=35.0n w=340.0n m=7
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0237 net0144 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S3 net0268 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_DPCK_T2S1 net0164 CP_minus net0144 VDD pch_mac l=35.0n w=325.00n m=5
XMP_SPIN_T1S3 net0280 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0269 CP_plus net0280 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_VDPINV_T1S1 net0168 net0164 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0248 net0168 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0164 CP_plus net0248 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0144 net92 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0237 VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPOUT_T3S1 QN net0164 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0276 VDD pch_mac l=35.0n w=340.0n m=4
XMP_SPIN_T1S1 net92 SEN net0269 VDD pch_mac l=35.0n w=120.0n m=1
XMN_VDPOUT_T2S1 Q net0168 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_CTL_T1S2 net0148 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0148 VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_LH1FB_T1S2 net0169 net0144 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPOUT_T3S1 QN net0164 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0192 VSS nch_mac l=35.0n w=280.0n m=4
XMN_KSNIN_T1S1 net92 SNB net0192 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0192 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0185 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0184 CP_minus net0185 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_VDPINV_T1S1 VSS net0164 net0168 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T2S1 net0164 CP_plus net0144 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net92 CP_plus net0169 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0152 net0168 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0164 CP_minus net0152 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0144 net92 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S1 net92 SE net0184 VSS nch_mac l=35.0n w=100n m=1
.ends
.subckt SDFKSNOPTMBD12BWP35 SI D SE CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0166 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_VDPINV_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=325.00n m=10
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=7
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=10
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=5
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPOUT_T2S1 QN net0166 VSS VSS nch_mac l=35.0n w=280.0n m=9
.ends
.subckt SDFKSNOPTMBD4BWP35 SI D SE CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0166 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_VDPINV_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPOUT_T2S1 QN net0166 VSS VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFKSNOPTMBD8BWP35 SI D SE CP SN Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0166 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_VDPINV_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=6
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPOUT_T2S1 QN net0166 VSS VSS nch_mac l=35.0n w=280.0n m=6
.ends
.subckt SDFKSNQOPTMAD12BWP35 SI D SE CP SN Q VDD VSS
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=7
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=10
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=5
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFKSNQOPTMAD4BWP35 SI D SE CP SN Q VDD VSS
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=4
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=195.00n m=1
.ends
.subckt SDFKSNQOPTMAD8BWP35 SI D SE CP SN Q VDD VSS
XMP_SNINV_T1S1 SNB SN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2 net0255 net0170 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_DPIN_T1S3 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMP_DPCK_T3S1 net0282 CP_minus net0187 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0170 net0282 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0231 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0230 CP_plus net0231 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S1 net92 D net0241 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S1 net92 SEN net0230 VDD pch_mac l=35.0n w=120.0n m=1
XMP_LH2FB_T2S2 net0270 net0166 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0187 CP_plus net0270 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0170 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0166 net0187 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0255 VDD pch_mac l=35.0n w=275.00n m=1
XMP_DPOUT_T4S1 Q net0187 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2 net0241 SNB net0199 VDD pch_mac l=35.0n w=340.0n m=6
XMN_SNINV_T1S1 SNB SN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0155 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0155 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net0195 net0170 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0170 net0191 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
XMN_KSNIN_T1S1 net92 SNB net0123 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0150 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0143 CP_minus net0150 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0143 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0191 CP_plus net0187 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0187 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0195 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0178 net0166 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0187 CP_minus net0178 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0170 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0166 net0187 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFMOPTMAD12BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_DPIN_T1S2B net0281 SA net0285 VDD pch_mac l=35.0n w=340.0n m=10
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2 net0253 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0296 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0289 CP_plus net0296 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0289 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPIN_T1S2A net0276 SAN net0285 VDD pch_mac l=35.0n w=340.0n m=10
XMP_VDPINV_T1S1 net0176 net0172 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPCK_T2S1 net0172 CP_minus net0137 VDD pch_mac l=35.0n w=325.00n m=10
XMP_LH2FB_T2S2 net0264 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0172 CP_plus net0264 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net92 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0253 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0172 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1B net92 DB net0281 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S3 net0285 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_DPIN_T1S1A net92 DA net0276 VDD pch_mac l=35.0n w=340.0n m=5
XMN_DPIN_T1S2B net0208 SAN net0204 VSS nch_mac l=35.0n w=280.0n m=10
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0152 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0152 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T3S1 QN net0172 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_DPIN_T1S2A net0201 SA net0204 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPIN_T1S1A net92 DA net0201 VSS nch_mac l=35.0n w=280.0n m=7
XMN_LH1FB_T1S2 net0177 net0137 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S3 net0204 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0189 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0188 CP_minus net0189 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0188 VSS nch_mac l=35.0n w=100n m=1
XMN_VDPINV_T1S1 VSS net0172 net0176 VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T2S1 net0172 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_LH1FB_T1S1 net92 CP_plus net0177 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0160 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0172 CP_minus net0160 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0137 net92 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1B net92 DB net0208 VSS nch_mac l=35.0n w=280.0n m=7
.ends
.subckt SDFMOPTMAD4BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_DPIN_T1S2B net0281 SA net0285 VDD pch_mac l=35.0n w=340.0n m=4
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2 net0253 net0137 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0296 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0289 CP_plus net0296 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0289 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S2A net0276 SAN net0285 VDD pch_mac l=35.0n w=340.0n m=4
XMP_VDPINV_T1S1 net0176 net0172 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T2S1 net0172 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T2S2 net0264 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0172 CP_plus net0264 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S2 net0137 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0253 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0172 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1B net92 DB net0281 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S3 net0285 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1A net92 DA net0276 VDD pch_mac l=35.0n w=340.0n m=2
XMN_DPIN_T1S2B net0208 SAN net0204 VSS nch_mac l=35.0n w=280.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0152 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0152 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPOUT_T3S1 QN net0172 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2A net0201 SA net0204 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1A net92 DA net0201 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0177 net0137 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S3 net0204 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0189 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0188 CP_minus net0189 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0188 VSS nch_mac l=35.0n w=100n m=1
XMN_VDPINV_T1S1 VSS net0172 net0176 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T2S1 net0172 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net92 CP_plus net0177 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0160 net0176 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0172 CP_minus net0160 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0137 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S1B net92 DB net0208 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFMOPTMAD8BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_DPIN_T1S2B net0281 SA net0285 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH1FB_T1S2 net0253 net0137 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0296 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0289 CP_plus net0296 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0289 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPIN_T1S2A net0276 SAN net0285 VDD pch_mac l=35.0n w=340.0n m=8
XMP_VDPINV_T1S1 net0176 net0172 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T2S1 net0172 CP_minus net0137 VDD pch_mac l=35.0n w=325.00n m=5
XMP_LH2FB_T2S2 net0264 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0172 CP_plus net0264 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S2 net0137 net92 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0253 VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPOUT_T3S1 QN net0172 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1B net92 DB net0281 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S3 net0285 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_DPIN_T1S1A net92 DA net0276 VDD pch_mac l=35.0n w=340.0n m=3
XMN_DPIN_T1S2B net0208 SAN net0204 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0152 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0152 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPOUT_T3S1 QN net0172 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S2A net0201 SA net0204 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1A net92 DA net0201 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0177 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPIN_T1S3 net0204 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0189 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0188 CP_minus net0189 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0188 VSS nch_mac l=35.0n w=100n m=1
XMN_VDPINV_T1S1 VSS net0172 net0176 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T2S1 net0172 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net92 CP_plus net0177 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0160 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0172 CP_minus net0160 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S2 net0137 net92 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S1B net92 DB net0208 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFMOPTMBD12BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0178 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=10
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_VDPINV_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=10
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=10
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=7
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=7
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=5
XMN_VDPINV_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPOUT_T2S1 QN net0178 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFMOPTMBD4BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0178 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=4
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_VDPINV_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=4
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=2
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPOUT_T2S1 QN net0178 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFMOPTMBD8BWP35 DA DB SA SI SE CP Q QN VDD VSS
XMP_VDPOUT_T2S1 QN net0178 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_VDPINV_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=5
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPINV_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPOUT_T2S1 QN net0178 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFMQOPTMAD12BWP35 DA DB SA SI SE CP Q VDD VSS
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=10
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=10
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=7
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=7
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFMQOPTMAD4BWP35 DA DB SA SI SE CP Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=4
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=4
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=195.00n m=1
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFMQOPTMAD8BWP35 DA DB SA SI SE CP Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S2B net0199 SA net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH1FB_T1S2 net0275 net0182 VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_SAINV_T1S1 SAN SA VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0302 CP_minus net0138 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S2 VDD net0182 net0302 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0311 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0310 CP_plus net0311 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0310 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2A net0229 SAN net0236 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH2FB_T2S2 net0290 net0178 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0138 CP_plus net0290 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0182 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0178 net0138 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net0275 VDD pch_mac l=35.0n w=275.00n m=1
XMP_DPOUT_T4S1 Q net0138 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1B net92 DB net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S3 net0236 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_DPIN_T1S1A net92 DA net0229 VDD pch_mac l=35.0n w=340.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S2B net0123 SAN net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_CTL_T1S1 CTRL CP_minus net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0167 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0207 net0182 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0182 net0203 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SAINV_T1S1 SAN SA VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2A net0140 SA net0137 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1A net92 DA net0140 VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S3 net0137 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0222 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0215 CP_minus net0222 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0215 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0203 CP_plus net0138 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0138 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net0207 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0190 net0178 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0138 CP_minus net0190 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0182 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0178 net0138 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1B net92 DB net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFOPTMAD12BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=200n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=9
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=7
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFOPTMAD4BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=200n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM1 net0176 net0167 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFOPTMAD8BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=5
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFOPTMBD12BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=10
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=8
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_VDPOUT_T2S1 QN net0176 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=8
XMN_VDPOUT_T2S1 QN net0176 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=10
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFOPTMBD4BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 QN net0176 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPOUT_T2S1 QN net0176 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFOPTMBD8BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_VDPOUT_T2S1 QN net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=5
XMN_VDPOUT_T2S1 QN net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFOPTSADD12BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=200n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=9
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=7
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFOPTSADD4BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM0 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=200n m=1
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
MM1 net0176 net0167 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=1
.ends
.subckt SDFOPTSADD8BWP35 SI D SE CP Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0176 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0229 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPCK_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S2 net0228 CP_plus net0229 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net0129 SEN net0228 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0129 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0212 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0212 VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net0129 CP_minus_mfb net0217 VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPINV_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S1 net0129 D net0213 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S2 net0213 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_LH1FB_T1S2 net0217 net0240 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_VDPOUT_T2S1 Q net0176 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPIN_T1S2 net0133 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_DPCK_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2 net0137 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_SPIN_T1S3 net0160 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0153 CP_minus net0160 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0129 SE net0153 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0129 CP_plus net0137 VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPINV_T2S2 net0240 net0129 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S2 net0136 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0136 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPIN_T1S1 net0129 D net0133 VSS nch_mac l=35.0n w=280.0n m=5
XMN_VDPINV_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFQNOPTMAD12BWP35 SI D SE CP QN VDD VSS
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=7
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
.ends
.subckt SDFQNOPTMAD4BWP35 SI D SE CP QN VDD VSS
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=135.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=135.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=135.00n m=1
.ends
.subckt SDFQNOPTMAD8BWP35 SI D SE CP QN VDD VSS
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
.ends
.subckt SDFQNOPTSADD12BWP35 SI D SE CP QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=9
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=7
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
.ends
.subckt SDFQNOPTSADD4BWP35 SI D SE CP QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=210.0n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=135.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=135.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=135.00n m=1
.ends
.subckt SDFQNOPTSADD8BWP35 SI D SE CP QN VDD VSS
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_SPIN_T1S2 net0216 CP_plus net0217 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S1 net0167 CP_minus net0240 VDD pch_mac l=35.0n w=325.00n m=5
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPIN_T1S1 net0121 D net0201 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2 net0201 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMP_SPIN_T1S1 net0121 SEN net0216 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPINV_T2S2 net0240 net0121 VDD VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0121 CP_minus_mfb net0205 VDD pch_mac l=35.0n w=270.0n m=1
XMP_LH2FB_T2S2 net0208 net0124 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0208 VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T1S1 net0124 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T3S1 QN net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S2 net0205 net0240 VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S3 net0217 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0138 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0138 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_LH1FB_T1S2 net0149 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_DPINV_T2S1 net0167 CP_plus net0240 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S2 net0125 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_DPIN_T1S1 net0121 D net0125 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S3 net0148 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0141 CP_minus net0148 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net0121 SE net0141 VSS nch_mac l=35.0n w=100n m=1
XMN_LH1FB_T1S1 net0121 CP_plus net0149 VSS nch_mac l=35.0n w=200n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPOUT_T3S1 QN net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPINV_T2S2 net0240 net0121 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH2FB_T2S2 net0132 net0124 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0132 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T1S1 net0124 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
.ends
.subckt SDFQOPTMAD12BWP35 SI D SE CP Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=9
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFQOPTMAD4BWP35 SI D SE CP Q VDD VSS
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFQOPTMAD8BWP35 SI D SE CP Q VDD VSS
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFQOPTSADD12BWP35 SI D SE CP Q VDD VSS
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=9
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=8
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=5
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=11
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=12
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=5
.ends
.subckt SDFQOPTSADD4BWP35 SI D SE CP Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=295.00n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=130.0n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=200n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=150.0n m=2
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=2
.ends
.subckt SDFQOPTSADD8BWP35 SI D SE CP Q VDD VSS
MM0 net92 D net0199 VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_LH1FB_T1S2 net200 net0240 VDD VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPCK_T3S1 net0190 CP_minus net0167 VDD pch_mac l=35.0n w=325.00n m=5
XMP_DPCK_T3S2 VDD net0240 net0190 VDD pch_mac l=35.0n w=340.0n m=5
XMP_SPIN_T1S3 net0207 SI VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net92 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_LH2FB_T2S2 net0312 net0176 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0312 VDD pch_mac l=35.0n w=200n m=1
XMP_DPINV_T2S1 net0240 net92 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0176 net0167 VDD VDD pch_mac l=35.0n w=200n m=1
XMP_LH1FB_T1S1 net92 CP_minus_mfb net200 VDD pch_mac l=35.0n w=280.0n m=1
XMP_DPOUT_T4S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPIN_T1S1 net92 D net0199 VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPIN_T1S2 net0199 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S1 CTRL CP_minus net0128 VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T1S2 net0128 SEN VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH1FB_T1S2 net090 net0240 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_DPCK_T3S2 VSS net0240 net0117 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPIN_T1S2 net0123 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S3 net0116 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S2 net0115 CP_minus net0116 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net92 SE net0115 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=100n m=4
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_DPCK_T3S1 net0117 CP_plus net0167 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T4S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net92 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S2 net0248 net0176 VSS VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH2FB_T2S1 net0167 CP_minus net0248 VSS nch_mac l=35.0n w=115.00n m=1
XMN_DPINV_T2S1 net0240 net92 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S1 net0176 net0167 VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_DPIN_T1S1 net92 D net0123 VSS nch_mac l=35.0n w=280.0n m=3
.ends
.subckt SDFSNOPTMAD12BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net090 D net0277 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH2FB_T1S1 net0254 CP_plus net0139 VDD pch_mac l=35.0n w=200n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S3 net0242 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S2B net0254 net0167 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S1 net0246 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0246 net0137 net0242 VDD pch_mac l=35.0n w=195.00n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=7
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=9
XMP_LH2FB_T1S2A net0254 SDN VDD VDD pch_mac l=35.0n w=200n m=2
XMP_SPIN_T1S3 net0262 SI net0270 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S4 net0270 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0261 CP_plus net0262 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_SPIN_T1S1 net090 SEN net0261 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0277 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=12
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=9
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_LH1FB_T1S1 net0150 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0201 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=7
XMN_LH1FB_T1S2A net0150 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0154 CP_minus net0139 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH1FB_T1S2B net0150 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T1S2 net0154 SDN net0146 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S3 net0146 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SPIN_T1S3 net0170 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0169 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=11
XMN_SPIN_T1S2 net0165 CP_minus net0170 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0165 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=9
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPIN_T1S1 net090 D net0169 VSS nch_mac l=35.0n w=280.0n m=7
XMN_CTL_T1S1 CTRL CP_minus net0182 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0182 SEN net0201 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNOPTMAD4BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPIN_T1S1 net090 D net0277 VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S1 net0254 CP_plus net0139 VDD pch_mac l=35.0n w=130.0n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S3 net0242 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S2B net0254 net0167 VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH1FB_T1S1 net0246 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0246 net0137 net0242 VDD pch_mac l=35.0n w=195.00n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH2FB_T1S2A net0254 SDN VDD VDD pch_mac l=35.0n w=140.0n m=1
XMP_SPIN_T1S3 net0262 SI net0270 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S4 net0270 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0261 CP_plus net0262 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S1 net090 SEN net0261 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0277 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S1 net0150 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0201 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2A net0150 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0154 CP_minus net0139 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH1FB_T1S2B net0150 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0154 SDN net0146 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH2FB_T1S3 net0146 net0167 VSS VSS nch_mac l=35.0n w=130.0n m=1
XMN_SPIN_T1S3 net0170 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0169 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S2 net0165 CP_minus net0170 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0165 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1 net090 D net0169 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T1S1 CTRL CP_minus net0182 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0182 SEN net0201 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNOPTMAD8BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
MM0 net0137 net090 VDD VDD pch_mac l=35.0n w=240.0n m=1
XMP_VDPOUT_T2S1 Q net0167 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_VDPINV_T1S1 net0167 net0139 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=240.0n m=2
XMP_DPIN_T1S1 net090 D net0277 VDD pch_mac l=35.0n w=340.0n m=3
XMP_LH2FB_T1S1 net0254 CP_plus net0139 VDD pch_mac l=35.0n w=200n m=1
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S3 net0242 net0130 VDD VDD pch_mac l=35.0n w=240.0n m=1
XMP_LH2FB_T1S2B net0254 net0167 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH1FB_T1S1 net0246 CP_minus_mfb net090 VDD pch_mac l=35.0n w=240.0n m=1
XMP_LH1FB_T1S2 net0246 net0137 net0242 VDD pch_mac l=35.0n w=240.0n m=1
XMP_DPINV_T2S2 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPCK_T2S1 net0139 CP_minus net0137 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH2FB_T1S2A net0254 SDN VDD VDD pch_mac l=35.0n w=200n m=1
XMP_SPIN_T1S3 net0262 SI net0270 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S4 net0270 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0261 CP_plus net0262 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_DPOUT_T3S1 QN net0139 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_SPIN_T1S1 net090 SEN net0261 VDD pch_mac l=35.0n w=120.0n m=1
XMP_DPIN_T1S2 net0277 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=8
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 Q net0167 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_LH1FB_T1S1 net0150 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0201 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S2 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S2A net0150 net0130 VSS VSS nch_mac l=35.0n w=165.00n m=1
XMN_LH2FB_T1S1 net0154 CP_minus net0139 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S2B net0150 net0137 VSS VSS nch_mac l=35.0n w=165.00n m=1
XMN_VDPINV_T1S1 VSS net0139 net0167 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH2FB_T1S2 net0154 SDN net0146 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S3 net0146 net0167 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_SPIN_T1S3 net0170 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0169 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=7
XMN_SPIN_T1S2 net0165 CP_minus net0170 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0165 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPCK_T2S1 net0139 CP_plus net0137 VSS nch_mac l=35.0n w=280.0n m=5
XMN_DPOUT_T3S1 QN net0139 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1 net090 D net0169 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T1S1 CTRL CP_minus net0182 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0182 SEN net0201 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNOPTMBD12BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 QN net0229 VDD VDD pch_mac l=35.0n w=340.0n m=9
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=190.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
MM0 net090 D net0256 VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPINV_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=190.0n m=2
XMP_VDPINV_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=330.0n m=9
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 QN net0229 VSS VSS nch_mac l=35.0n w=280.0n m=9
MM1 net090 D net0220 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=195.00n m=2
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=195.00n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_VDPINV_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=3
XMN_VDPINV_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=9
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNOPTMBD4BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_VDPOUT_T2S1 QN net0229 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_VDPINV_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=140.0n m=1
XMP_VDPINV_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 QN net0229 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=130.0n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_VDPINV_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_VDPINV_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNOPTMBD8BWP35 SI D SE CP SDN Q QN VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
MM0 net090 D net0256 VDD pch_mac l=35.0n w=270.0n m=2
XMP_VDPOUT_T2S1 QN net0229 VDD VDD pch_mac l=35.0n w=340.0n m=6
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_VDPINV_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=130.0n m=1
XMP_VDPINV_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=330.0n m=5
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_VDPOUT_T2S1 QN net0229 VSS VSS nch_mac l=35.0n w=280.0n m=6
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=115.00n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_VDPINV_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=2
XMN_VDPINV_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNQOPTMAD12BWP35 SI D SE CP SDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=5
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=8
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=130.0n m=2
XMP_LH2FB_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
MM0 net090 D net0256 VDD pch_mac l=35.0n w=270.0n m=1
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=12
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=330.0n m=9
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=13
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
MM1 net090 D net0220 VSS nch_mac l=35.0n w=210.0n m=1
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=150.0n m=2
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=8
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=3
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=120.0n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=9
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=13
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=12
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=5
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNQOPTMAD4BWP35 SI D SE CP SDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=2
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=140.0n m=1
XMP_LH2FB_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=4
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=4
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=340.0n m=2
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=4
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=130.0n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=130.0n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=2
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=3
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=4
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=2
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SDFSNQOPTMAD8BWP35 SI D SE CP SDN Q VDD VSS
XMP_CKIN_T3S1 CP_minus_mfb CP_plus VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SDNINV_T1S1 VDD SDN net0130 VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S1 net0167 CP_plus net0141 VDD pch_mac l=35.0n w=130.0n m=1
XMP_DPIN_T1S1 net090 D net0256 VDD pch_mac l=35.0n w=340.0n m=3
XMP_CTL_T2S1 CTRL_N CTRL VDD VDD pch_mac l=35.0n w=270.0n m=1
XMP_SEINV_T1S1 SEN SE VDD VDD pch_mac l=35.0n w=275.00n m=1
XMP_LH1FB_T1S3 net0226 net0130 VDD VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH2FB_T1S1A net0229 net0141 VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPCK_T3S2 VDD net0137 net0247 VDD pch_mac l=35.0n w=340.0n m=5
XMP_LH1FB_T1S1 net0224 CP_minus_mfb net090 VDD pch_mac l=35.0n w=195.00n m=1
XMP_LH1FB_T1S2 net0224 net0137 net0226 VDD pch_mac l=35.0n w=195.00n m=1
XMP_CTL_T1S1B CTRL SEN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_DPINV_T2S1 net0137 net090 VDD VDD pch_mac l=35.0n w=340.0n m=2
XMP_CTL_T1S1A CTRL CP_minus VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S3 net0263 SI net0207 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CTL_T1S1C CTRL SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_LH2FB_T2S2 VDD net0229 net0167 VDD pch_mac l=35.0n w=130.0n m=1
MM0 net090 D net0256 VDD pch_mac l=35.0n w=270.0n m=2
XMP_LH2FB_T1S1B net0229 SDN VDD VDD pch_mac l=35.0n w=340.0n m=1
XMP_SPIN_T1S4 net0207 net0130 VDD VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S2 net0200 CP_plus net0263 VDD pch_mac l=35.0n w=120.0n m=1
XMP_SPIN_T1S1 net090 SEN net0200 VDD pch_mac l=35.0n w=120.0n m=1
XMP_CKIN_T2S1 CP_plus CP_minus VDD VDD pch_mac l=35.0n w=270.0n m=5
XMP_CKIN_T1S1 CP_minus CP VDD VDD pch_mac l=35.0n w=270.0n m=2
XMP_DPOUT_T4S1 Q net0141 VDD VDD pch_mac l=35.0n w=340.0n m=8
XMP_DPCK_T3S1 net0247 CP_minus net0141 VDD pch_mac l=35.0n w=330.0n m=5
XMP_DPIN_T1S2 net0256 CTRL VDD VDD pch_mac l=35.0n w=270.0n m=7
XMN_CKIN_T3S1 CP_minus_mfb CP_plus VSS VSS nch_mac l=35.0n w=270.0n m=1
XMN_LH2FB_T2S2 VSS net0229 net0151 VSS nch_mac l=35.0n w=115.00n m=1
XMN_KSNIN_T1S1 net090 net0130 VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_DPCK_T3S2 VSS net0137 net0135 VSS nch_mac l=35.0n w=280.0n m=5
XMN_LH1FB_T1S1 net0136 CP_plus net090 VSS nch_mac l=35.0n w=200n m=1
XMN_CTL_T2S1 CTRL_N CTRL VSS VSS nch_mac l=35.0n w=210.0n m=1
XMN_SEINV_T1S1 SEN SE VSS VSS nch_mac l=35.0n w=155.00n m=1
XMN_CTL_T1S3 net0150 SDN VSS VSS nch_mac l=35.0n w=260.0n m=1
XMN_SDNINV_T1S1 VSS SDN net0130 VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPINV_T2S1 net0137 net090 VSS VSS nch_mac l=35.0n w=280.0n m=2
XMN_LH1FB_T1S2A net0136 net0130 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T2S1 net0151 CP_minus net0141 VSS nch_mac l=35.0n w=115.00n m=1
XMN_LH1FB_T1S2B net0136 net0137 VSS VSS nch_mac l=35.0n w=200n m=1
XMN_LH2FB_T1S1 net0229 SDN net0147 VSS nch_mac l=35.0n w=280.0n m=1
XMN_LH2FB_T1S2 net0147 net0141 VSS VSS nch_mac l=35.0n w=280.0n m=1
XMN_DPCK_T3S1 net0135 CP_plus net0141 VSS nch_mac l=35.0n w=280.0n m=5
XMN_SPIN_T1S3 net0159 SI VSS VSS nch_mac l=35.0n w=100n m=1
XMN_DPIN_T1S2 net0220 CTRL_N VSS VSS nch_mac l=35.0n w=210.0n m=8
XMN_SPIN_T1S2 net0152 CP_minus net0159 VSS nch_mac l=35.0n w=100n m=1
XMN_SPIN_T1S1 net090 SE net0152 VSS nch_mac l=35.0n w=100n m=1
XMN_CKIN_T2S1 CP_plus CP_minus VSS VSS nch_mac l=35.0n w=270.0n m=2
XMN_CKIN_T1S1 CP_minus CP VSS VSS nch_mac l=35.0n w=210.0n m=4
XMN_DPOUT_T4S1 Q net0141 VSS VSS nch_mac l=35.0n w=280.0n m=8
XMN_DPIN_T1S1 net090 D net0220 VSS nch_mac l=35.0n w=280.0n m=3
XMN_CTL_T1S1 CTRL CP_minus net0145 VSS nch_mac l=35.0n w=260.0n m=1
XMN_CTL_T1S2 net0145 SEN net0150 VSS nch_mac l=35.0n w=260.0n m=1
.ends
.subckt SEDFQND1BWP35 E SE CP SI D QN VDD VSS
MM0 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net13 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM24 net24 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net21 D net24 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM48 net29 net73 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net40 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net40 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net61 VSS nch_mac l=35.0n w=190.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net61 SE net29 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net21 net77 net69 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net69 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM16 net73 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net77 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM28 net81 net13 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net61 net21 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM9 qf_x clkb net92 VSS nch_mac l=35.0n w=100n m=1
MM10 net92 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM1 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM3 net13 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM13 net77 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net116 net77 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net21 D net116 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net21 E net125 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net125 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net169 VDD pch_mac l=35.0n w=200n m=1
MM60 net156 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 net21 net157 VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net156 VDD pch_mac l=35.0n w=100n m=1
MM43 net157 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM15 net73 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net169 net13 net173 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net173 net73 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net177 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 qf_x clkbb net177 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQND2BWP35 E SE CP SI D QN VDD VSS
MM10 net104 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf_x clkb net104 VSS nch_mac l=35.0n w=100n m=1
MM27 net129 net169 net108 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net108 net177 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net113 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net117 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net128 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net169 net113 net128 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net129 SE net161 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net129 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net157 VSS nch_mac l=35.0n w=100n m=1
MM65 net157 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM48 net161 net117 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=260.0n m=1
MM23 net169 D net173 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net173 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net177 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM0 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 qf_x clkbb net13 VDD pch_mac l=35.0n w=295.00n m=1
MM5 net13 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM25 net24 net117 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net21 net177 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net117 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM43 net44 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net40 VDD pch_mac l=35.0n w=100n m=1
MM44 net21 net169 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM60 net40 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq clkbb net21 VDD pch_mac l=35.0n w=200n m=1
MM17 net72 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net169 E net72 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net169 D net81 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net81 net113 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net113 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net177 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM1 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt SEDFQND4BWP35 E SE CP SI D QN VDD VSS
MM0 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net101 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM24 net24 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net21 D net24 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=260.0n m=1
MM48 net64 net165 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net40 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net40 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net61 VSS nch_mac l=35.0n w=190.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net61 SE net64 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net21 net105 net69 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net69 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM16 net165 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net105 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM28 net81 net101 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net61 net21 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM9 qf_x clkb net92 VSS nch_mac l=35.0n w=100n m=1
MM10 net92 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM1 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=4
MM3 net101 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM13 net105 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net116 net105 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net21 D net116 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net21 E net124 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net124 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net169 VDD pch_mac l=35.0n w=200n m=1
MM60 net156 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM44 net169 net21 net157 VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net156 VDD pch_mac l=35.0n w=100n m=1
MM43 net157 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM15 net165 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net169 net101 net173 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net173 net165 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net177 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 qf_x clkbb net177 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFQD1BWP35 E SE CP SI D Q VDD VSS
MM10 net97 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM9 qf_x clkb net97 VSS nch_mac l=35.0n w=100n m=1
MM27 net129 net169 net108 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net108 net89 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net85 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM16 net25 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM19 net121 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net169 net85 net121 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net129 SE net161 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net129 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net157 VSS nch_mac l=35.0n w=100n m=1
MM65 net157 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM48 net161 net25 VSS VSS nch_mac l=35.0n w=140.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM23 net169 D net173 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net173 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM2 net89 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 qf_x clkbb net13 VDD pch_mac l=35.0n w=295.00n m=1
MM5 net13 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM25 net24 net25 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net21 net89 net24 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net25 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM43 net44 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net57 VDD pch_mac l=35.0n w=100n m=1
MM44 net21 net169 net44 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM60 net57 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM45 mq clkbb net21 VDD pch_mac l=35.0n w=200n m=1
MM17 net72 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net169 E net72 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net169 D net81 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net81 net85 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net85 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM3 net89 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt SEDFQD2BWP35 E SE CP SI D Q VDD VSS
MM0 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net101 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM24 net24 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net21 D net24 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=260.0n m=1
MM48 net29 net165 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM65 net40 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net40 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net61 VSS nch_mac l=35.0n w=190.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net61 SE net29 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net21 net105 net69 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net69 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM16 net165 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM14 net105 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM28 net81 net101 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net61 net21 net81 VSS nch_mac l=35.0n w=140.0n m=1
MM9 qf_x clkb net93 VSS nch_mac l=35.0n w=100n m=1
MM10 net93 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM1 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM3 net101 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM13 net105 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM22 net116 net105 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net21 D net116 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net21 E net125 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net125 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net169 VDD pch_mac l=35.0n w=200n m=1
MM60 net156 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net169 net21 net157 VDD pch_mac l=35.0n w=170.0n m=1
MM79 mq clkb net156 VDD pch_mac l=35.0n w=100n m=1
MM43 net157 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM15 net165 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net169 net101 net172 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net172 net165 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM5 net177 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM4 qf_x clkbb net177 VDD pch_mac l=35.0n w=295.00n m=1
.ends
.subckt SEDFD1BWP35 E SE CP SI D Q QN VDD VSS
MM32 net10 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM12 net114 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM27 net46 net94 net21 VSS nch_mac l=35.0n w=140.0n m=1
MM28 net21 net110 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM14 net190 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM16 net110 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM31 qf_x clkb net10 VSS nch_mac l=35.0n w=100n m=1
MM19 net38 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM20 net94 net114 net38 VSS nch_mac l=35.0n w=155.00n m=1
MM47 net46 SE net82 VSS nch_mac l=35.0n w=140.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net46 VSS nch_mac l=35.0n w=190.0n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM64 mq clkbb net74 VSS nch_mac l=35.0n w=100n m=1
MM65 net74 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM48 net82 net190 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=265.00n m=1
MM23 net94 D net97 VSS nch_mac l=35.0n w=155.00n m=1
MM24 net97 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM25 net102 net190 VDD VDD pch_mac l=35.0n w=170.0n m=1
MM26 net106 net110 net102 VDD pch_mac l=35.0n w=170.0n m=1
MM15 net110 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM11 net114 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM29 qf_x clkbb net126 VDD pch_mac l=35.0n w=295.00n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM30 net126 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
MM43 net145 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM79 mq clkb net158 VDD pch_mac l=35.0n w=100n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net106 net94 net145 VDD pch_mac l=35.0n w=170.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM60 net158 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=1
MM45 mq clkbb net106 VDD pch_mac l=35.0n w=200n m=1
MM17 net177 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM18 net94 E net177 VDD pch_mac l=35.0n w=155.00n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 net94 D net185 VDD pch_mac l=35.0n w=250.0n m=1
MM22 net185 net114 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM13 net190 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt SEDFD2BWP35 E SE CP SI D Q QN VDD VSS
MM24 net109 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM23 net106 D net109 VSS nch_mac l=35.0n w=155.00n m=1
XMSLTn1 qf_x clkbb mq_x VSS nch_mac l=35.0n w=260.0n m=1
MM73 QN qf VSS VSS nch_mac l=35.0n w=280.0n m=2
MM48 net157 net174 VSS VSS nch_mac l=35.0n w=140.0n m=1
MM71 Q qf_x VSS VSS nch_mac l=35.0n w=280.0n m=2
MM65 net126 mq_x VSS VSS nch_mac l=35.0n w=100n m=1
MM64 mq clkbb net126 VSS nch_mac l=35.0n w=100n m=1
MM55 clkbb clkb VSS VSS nch_mac l=35.0n w=280.0n m=1
MM46 mq clkb net154 VSS nch_mac l=35.0n w=190.0n m=1
MM76 qf qf_x VSS VSS nch_mac l=35.0n w=280.0n m=1
MM49 mq_x mq VSS VSS nch_mac l=35.0n w=280.0n m=1
MM53 clkb CP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM47 net154 SE net157 VSS nch_mac l=35.0n w=140.0n m=1
MM20 net106 net86 net161 VSS nch_mac l=35.0n w=155.00n m=1
MM19 net161 qf VSS VSS nch_mac l=35.0n w=155.00n m=1
MM31 qf_x clkb net190 VSS nch_mac l=35.0n w=100n m=1
MM16 net170 SE VSS VSS nch_mac l=35.0n w=120.0n m=1
MM14 net174 SI VSS VSS nch_mac l=35.0n w=140.0n m=1
MM28 net178 net170 VSS VSS nch_mac l=35.0n w=160.0n m=1
MM27 net154 net106 net178 VSS nch_mac l=35.0n w=140.0n m=1
MM12 net86 E VSS VSS nch_mac l=35.0n w=230.0n m=1
MM32 net190 qf VSS VSS nch_mac l=35.0n w=100n m=1
MM13 net174 SI VDD VDD pch_mac l=35.0n w=170.0n m=1
MM22 net21 net86 VDD VDD pch_mac l=35.0n w=250.0n m=1
MM21 net106 D net21 VDD pch_mac l=35.0n w=250.0n m=1
MM8 clkb CP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM18 net106 E net30 VDD pch_mac l=35.0n w=155.00n m=1
MM17 net30 qf VDD VDD pch_mac l=35.0n w=155.00n m=1
MM45 mq clkbb net94 VDD pch_mac l=35.0n w=200n m=1
MM74 QN qf VDD VDD pch_mac l=35.0n w=340.0n m=2
MM60 net42 mq_x VDD VDD pch_mac l=35.0n w=100n m=1
MM50 mq_x mq VDD VDD pch_mac l=35.0n w=295.00n m=1
MM56 clkbb clkb VDD VDD pch_mac l=35.0n w=340.0n m=1
MM77 qf qf_x VDD VDD pch_mac l=35.0n w=340.0n m=1
MM44 net94 net106 net61 VDD pch_mac l=35.0n w=170.0n m=1
MM72 Q qf_x VDD VDD pch_mac l=35.0n w=340.0n m=2
MM79 mq clkb net42 VDD pch_mac l=35.0n w=100n m=1
MM43 net61 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM30 net85 qf VDD VDD pch_mac l=35.0n w=120.0n m=1
XMSLTp1 qf_x clkb mq_x VDD pch_mac l=35.0n w=295.00n m=1
MM29 qf_x clkbb net85 VDD pch_mac l=35.0n w=295.00n m=1
MM11 net86 E VDD VDD pch_mac l=35.0n w=120.0n m=1
MM15 net170 SE VDD VDD pch_mac l=35.0n w=290.0n m=1
MM26 net94 net170 net98 VDD pch_mac l=35.0n w=170.0n m=1
MM25 net98 net174 VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt ISOHID1BWP35 ISO I Z VDD VSS
MM9 net6 I VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net6 ISO VSS VSS nch_mac l=35n w=280.0n m=1
MM0 Z net6 VSS VSS nch_mac l=35n w=280.0n m=1
MM7 net25 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM3 net6 I net25 VDD pch_mac l=35n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35n w=340.0n m=1
.ends
.subckt ISOHID2BWP35 ISO I Z VDD VSS
MM9 net6 I VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net6 ISO VSS VSS nch_mac l=35n w=280.0n m=1
MM0 Z net6 VSS VSS nch_mac l=35n w=280.0n m=2
MM7 net25 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM3 net6 I net25 VDD pch_mac l=35n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35n w=340.0n m=2
.ends
.subckt ISOHID4BWP35 ISO I Z VDD VSS
MM9 net6 I VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net6 ISO VSS VSS nch_mac l=35n w=280.0n m=1
MM0 Z net6 VSS VSS nch_mac l=35n w=280.0n m=4
MM7 net25 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM3 net6 I net25 VDD pch_mac l=35n w=340.0n m=1
MM1 Z net6 VDD VDD pch_mac l=35n w=340.0n m=4
.ends
.subckt ISOHID8BWP35 ISO I Z VDD VSS
MM9 net054 I VSS VSS nch_mac l=35n w=280.0n m=3
MM8 net054 ISO VSS VSS nch_mac l=35n w=280.0n m=3
MM0 Z net054 VSS VSS nch_mac l=35n w=280.0n m=8
MM4 net054 I net023 VDD pch_mac l=35n w=340.0n m=1
MM2 net023 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM5 net054 I net034 VDD pch_mac l=35n w=340.0n m=1
MM6 net034 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM7 net25 ISO VDD VDD pch_mac l=35n w=340.0n m=1
MM3 net054 I net25 VDD pch_mac l=35n w=340.0n m=1
MM1 Z net054 VDD VDD pch_mac l=35n w=340.0n m=8
.ends
.subckt ISOLOD1BWP35 ISO I Z VDD VSS
MM9 net14 net046 VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net049 I net14 VSS nch_mac l=35n w=280.0n m=1
MM3 net046 ISO VSS VSS nch_mac l=35n w=140.0n m=1
MM5 Z net049 VSS VSS nch_mac l=35n w=280.0n m=1
MM6 net049 I VDD VDD pch_mac l=35n w=340.0n m=1
MM7 net049 net046 VDD VDD pch_mac l=35n w=340.0n m=1
MM2 net046 ISO VDD VDD pch_mac l=35n w=170.0n m=1
MM4 Z net049 VDD VDD pch_mac l=35n w=340.0n m=1
.ends
.subckt ISOLOD2BWP35 ISO I Z VDD VSS
MM3 net050 ISO VSS VSS nch_mac l=35n w=140.0n m=1
MM9 net14 net050 VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net26 I net14 VSS nch_mac l=35n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35n w=280.0n m=2
MM2 net050 ISO VDD VDD pch_mac l=35n w=170.0n m=1
MM6 net26 I VDD VDD pch_mac l=35n w=340.0n m=1
MM7 net26 net050 VDD VDD pch_mac l=35n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35n w=340.0n m=2
.ends
.subckt ISOLOD4BWP35 ISO I Z VDD VSS
MM9 net14 net027 VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net26 I net14 VSS nch_mac l=35n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35n w=280.0n m=4
MM3 net027 ISO VSS VSS nch_mac l=35n w=140.0n m=1
MM6 net26 I VDD VDD pch_mac l=35n w=340.0n m=1
MM7 net26 net027 VDD VDD pch_mac l=35n w=340.0n m=1
MM4 Z net26 VDD VDD pch_mac l=35n w=340.0n m=4
MM2 net027 ISO VDD VDD pch_mac l=35n w=170.0n m=1
.ends
.subckt ISOLOD8BWP35 ISO I Z VDD VSS
MM11 net045 net027 VSS VSS nch_mac l=35n w=280.0n m=1
MM10 net26 I net045 VSS nch_mac l=35n w=280.0n m=1
MM9 net14 net027 VSS VSS nch_mac l=35n w=280.0n m=1
MM8 net26 I net14 VSS nch_mac l=35n w=280.0n m=1
MM5 Z net26 VSS VSS nch_mac l=35n w=280.0n m=8
MM0 net060 net027 VSS VSS nch_mac l=35n w=280.0n m=1
MM3 net027 ISO VSS VSS nch_mac l=35n w=280.0n m=1
MM1 net26 I net060 VSS nch_mac l=35n w=280.0n m=1
MM6 net26 I VDD VDD pch_mac l=35n w=340.0n m=3
MM7 net26 net027 VDD VDD pch_mac l=35n w=340.0n m=3
MM4 Z net26 VDD VDD pch_mac l=35n w=340.0n m=8
MM2 net027 ISO VDD VDD pch_mac l=35n w=340.0n m=1
.ends
.subckt LVLHLCD1BWP35 I NSLEEP Z VDD VSS
MM1 net41 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net37 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net41 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 net41 net37 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net41 I net45 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net37 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Z net41 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net45 net37 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCD2BWP35 I NSLEEP Z VDD VSS
MM1 net0103 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM4 net084 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net0103 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net0103 net084 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM11 net0103 I net069 VDD pch_mac l=35.0n w=340.0n m=1
MM12 net084 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM13 Z net0103 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net069 net084 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCD4BWP35 I NSLEEP Z VDD VSS
MM4 net44 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net52 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM1 net52 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 net52 net44 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM7 net28 net44 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM13 Z net52 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM11 net52 I net28 VDD pch_mac l=35.0n w=340.0n m=2
MM12 net44 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCD8BWP35 I NSLEEP Z VDD VSS
MM0 net32 net40 VSS VSS nch_mac l=35.0n w=280.0n m=3
MM4 net40 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net32 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM1 net32 I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM13 Z net32 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM7 net46 net40 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM11 net32 I net46 VDD pch_mac l=35.0n w=340.0n m=3
MM12 net40 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCLOD1BWP35 I NSLEEP Z VDD VSS
MM8 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 net32 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net28 I net32 VSS nch_mac l=35.0n w=280.0n m=1
MM9 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 net28 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net28 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCLOD2BWP35 I NSLEEP Z VDD VSS
MM8 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net32 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=1
MM3 net28 I net32 VSS nch_mac l=35.0n w=280.0n m=1
MM9 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net28 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM7 net28 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLHLCLOD4BWP35 I NSLEEP Z VDD VSS
MM8 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net32 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=2
MM3 net28 I net32 VSS nch_mac l=35.0n w=280.0n m=2
MM9 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net28 I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM7 net28 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LVLHLCLOD8BWP35 I NSLEEP Z VDD VSS
MM8 Z net28 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 net32 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=3
MM3 net28 I net32 VSS nch_mac l=35.0n w=280.0n m=3
MM9 Z net28 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM6 net28 I VDD VDD pch_mac l=35.0n w=340.0n m=3
MM7 net28 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt LVLHLD1BWP35 I Z VDD VSS
MM0 net32 I VSS VSS nch_mac l=35.0n w=140.0n m=1
MM5 Z net32 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM13 Z net32 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM11 net32 I VDD VDD pch_mac l=35.0n w=170.0n m=1
.ends
.subckt LVLHLD2BWP35 I Z VDD VSS
MM5 net8 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM0 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM4 net8 I VDD VDD pch_mac l=35.0n w=340.0n m=1
MM1 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LVLHLD4BWP35 I Z VDD VSS
MM5 net029 I VSS VSS nch_mac l=35.0n w=280.0n m=2
MM0 Z net029 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM4 net029 I VDD VDD pch_mac l=35.0n w=340.0n m=2
MM1 Z net029 VDD VDD pch_mac l=35.0n w=340.0n m=4
.ends
.subckt LVLHLD8BWP35 I Z VDD VSS
MM5 net8 I VSS VSS nch_mac l=35.0n w=280.0n m=3
MM0 Z net8 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM4 net8 I VDD VDD pch_mac l=35.0n w=340.0n m=3
MM1 Z net8 VDD VDD pch_mac l=35.0n w=340.0n m=8
.ends
.subckt LVLLHCD1BWP35 I NSLEEP Z VDD VDDL VSS
MM10 N2 N0 N5 VSS nch_mac l=35.0n w=280.0n m=1
MM15 N3 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM12 N5 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 Z N3 N5 VSS nch_mac l=35.0n w=280.0n m=1
MM2 N0 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM14 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM16 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM0 Z NSLEEP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM9 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM6 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt LVLLHCD2BWP35 I NSLEEP Z VDD VDDL VSS
MM10 N2 N0 N5 VSS nch_mac l=35.0n w=280.0n m=1
MM15 N3 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM12 N5 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 Z N3 N5 VSS nch_mac l=35.0n w=280.0n m=2
MM2 N0 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM14 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM16 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM0 Z NSLEEP VDD VDD pch_mac l=35.0n w=170.0n m=1
MM4 Z N3 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM9 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM6 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt LVLLHCD4BWP35 I NSLEEP Z VDD VDDL VSS
MM10 N2 N0 N5 VSS nch_mac l=35.0n w=280.0n m=1
MM15 N3 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM12 N5 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM5 Z N3 N5 VSS nch_mac l=35.0n w=280.0n m=4
MM2 N0 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM14 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM16 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM0 Z NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM4 Z N3 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM9 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM6 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt LVLLHCD8BWP35 I NSLEEP Z VDD VDDL VSS
MM2 N0 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM10 N2 N0 N5 VSS nch_mac l=35.0n w=280.0n m=1
MM15 N3 I N5 VSS nch_mac l=35.0n w=280.0n m=1
MM12 N5 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=8
MM5 Z N3 N5 VSS nch_mac l=35.0n w=280.0n m=8
MM4 Z N3 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM9 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM6 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM17 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM14 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM16 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM0 Z NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLLHCLOD1BWP35 I NSLEEP Z VDD VDDL VSS
MM27 N6 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM28 N3 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM29 N2 N0 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM30 N0 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N7 N5 N8 VSS nch_mac l=35.0n w=280.0n m=1
MM32 N8 NSLEEP N6 VSS nch_mac l=35.0n w=280.0n m=1
MM19 Z N7 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM33 N5 N3 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM31 N5 N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM22 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM24 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM25 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM26 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM16 N7 N5 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 N7 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 Z N7 VDD VDD pch_mac l=35.0n w=340.0n m=1
.ends
.subckt LVLLHCLOD2BWP35 I NSLEEP Z VDD VDDL VSS
MM33 N5 N3 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM27 N6 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM28 N3 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM29 N2 N0 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM30 N0 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N7 N5 N8 VSS nch_mac l=35.0n w=280.0n m=1
MM32 N8 NSLEEP N6 VSS nch_mac l=35.0n w=280.0n m=1
MM19 Z N7 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM16 N7 N5 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 N7 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 Z N7 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM31 N5 N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM22 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM24 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM25 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM26 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
.ends
.subckt LVLLHCLOD4BWP35 I NSLEEP Z VDD VDDL VSS
MM33 N5 N3 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM27 N6 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=4
MM28 N3 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM29 N2 N0 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM30 N0 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N7 N5 N8 VSS nch_mac l=35.0n w=280.0n m=1
MM32 N8 NSLEEP N6 VSS nch_mac l=35.0n w=280.0n m=1
MM19 Z N7 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM16 N7 N5 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM15 N7 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=1
MM20 Z N7 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM31 N5 N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM21 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM22 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM24 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM25 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM26 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
.ends
.subckt LVLLHCLOD8BWP35 I NSLEEP Z VDD VDDL VSS
MM27 N6 NSLEEP VSS VSS nch_mac l=35.0n w=280.0n m=8
MM28 N3 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM29 N2 N0 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM30 N0 I N6 VSS nch_mac l=35.0n w=280.0n m=1
MM17 N7 N5 N8 VSS nch_mac l=35.0n w=280.0n m=1
MM1 N9 NSLEEP N6 VSS nch_mac l=35.0n w=280.0n m=1
MM0 N7 N5 N9 VSS nch_mac l=35.0n w=280.0n m=1
MM32 N8 NSLEEP N6 VSS nch_mac l=35.0n w=280.0n m=1
MM19 Z N7 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM33 N5 N3 N6 VSS nch_mac l=35.0n w=280.0n m=1
MM20 Z N7 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM21 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM22 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM24 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM25 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM26 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM31 N5 N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM16 N7 N5 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM15 N7 NSLEEP VDD VDD pch_mac l=35.0n w=340.0n m=2
.ends
.subckt LVLLHD1BWP35 I Z VDD VDDL VSS
MM15 N3 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 N2 N0 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM2 N0 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z N3 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM17 N3 I N4 VDD pch_mac l=35.0n w=340.0n m=3
MM9 N1 N3 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 N2 N0 N1 VDD pch_mac l=35.0n w=105.00n m=1
MM14 N0 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM4 Z N3 VDD VDD pch_mac l=35.0n w=340.0n m=1
MM6 N4 N2 VDD VDD pch_mac l=35.0n w=340.0n m=3
.ends
.subckt LVLLHD2BWP35 I Z VDD VDDL VSS
MM15 net46 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net64 net57 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=2
MM2 net57 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net57 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM4 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=2
MM6 net49 net64 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM17 net46 I net49 VDD pch_mac l=35.0n w=340.0n m=3
MM9 net44 net46 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 net64 net57 net44 VDD pch_mac l=35.0n w=105.00n m=1
.ends
.subckt LVLLHD4BWP35 I Z VDD VDDL VSS
MM15 net46 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net64 net57 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=4
MM2 net57 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net57 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM4 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=4
MM6 net49 net64 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM17 net46 I net49 VDD pch_mac l=35.0n w=340.0n m=3
MM9 net44 net46 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 net64 net57 net44 VDD pch_mac l=35.0n w=105.00n m=1
.ends
.subckt LVLLHD8BWP35 I Z VDD VDDL VSS
MM15 net46 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM10 net64 net57 VSS VSS nch_mac l=35.0n w=280.0n m=1
MM5 Z net46 VSS VSS nch_mac l=35.0n w=280.0n m=8
MM2 net57 I VSS VSS nch_mac l=35.0n w=280.0n m=1
MM14 net57 I VDDL VDDL pch_mac l=35.0n w=340.0n m=1
MM4 Z net46 VDD VDD pch_mac l=35.0n w=340.0n m=8
MM6 net49 net64 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM17 net46 I net49 VDD pch_mac l=35.0n w=340.0n m=3
MM9 net44 net46 VDD VDD pch_mac l=35.0n w=340.0n m=3
MM16 net64 net57 net44 VDD pch_mac l=35.0n w=105.00n m=1
.ends
